# EAGLE schematic main_new (EAGLE 7.6.0), part 2 of 2
## Nets (continued)
Unconnected: IC1.11(CLK) IC1.18(8D) IC2.12(Y7) IC2.13(Y6) IC2.14(Y5) IC3.12(Y7) IC3.13(Y6) IC3.14(Y5) IC4.11(CLK) IC5.11(CLK) IC6.4(2D) IC6.7(3D) IC6.8(4D) IC6.11(CLK) IC6.13(5D) IC6.14(6D) IC6.17(7D) IC7.4(2D) IC7.7(3D) IC7.8(4D) IC7.13(5D) IC7.14(6D) IC7.17(7D) IC9.12(Y7) IC9.13(Y6) IC9.14(Y5) IC10.3(B:Y4) IC10.5(B:Y3) IC10.7(B:Y2) IC10.9(B:Y1) IC10.11(B:A1) IC10.13(B:A2) IC10.15(B:A3) IC10.17(B:A4) IC10.19(B:G) IC11.3(B:Y4) IC11.5(B:Y3) IC11.7(B:Y2) IC11.9(B:Y1) IC11.11(B:A1) IC11.13(B:A2) IC11.15(B:A3) IC11.17(B:A4) IC11.19(B:G) IC12.3(B:Y4) IC12.5(B:Y3) IC12.7(B:Y2) IC12.9(B:Y1) IC12.11(B:A1) IC12.13(B:A2) IC12.15(B:A3) IC12.17(B:A4) IC12.19(B:G) IC13.3(B:Y4) IC13.5(B:Y3) IC13.7(B:Y2) IC13.9(B:Y1) IC13.11(B:A1) IC13.13(B:A2) IC13.15(B:A3) IC13.17(B:A4) IC13.19(B:G) IC14.14(A=B) IC14.15(P) IC14.17(G) IC15.14(A=B) IC15.15(P) IC15.17(G) IC16.11(CLK) IC17.11(CLK) IC18.1(A:I0) IC18.2(A:I1) IC18.3(A:O) IC18.8(C:O) IC18.9(C:I0) IC18.10(C:I1) IC18.11(D:O) IC18.12(D:I0) IC18.13(D:I1) IC19.2(A1) IC19.3(A2) IC19.4(A3) IC19.5(A4) IC19.6(A5) IC19.7(A6) IC19.8(A7) IC19.9(A8) IC19.12(Y7) IC19.13(Y6) IC19.19(G2) IC20.5(Q2) IC20.6(Q3) IC20.9(Q4) IC20.11(CLK) IC20.12(Q5) IC20.15(Q6) IC20.16(Q7) IC21.11(CLK) IC24.1(A:G) IC24.2(A:A1) IC24.4(A:A2) IC24.6(A:A3) IC24.8(A:A4) IC24.12(A:Y4) IC24.14(A:Y3) IC24.16(A:Y2) IC24.18(A:Y1) IC25.1(A:G) IC25.2(A:A1) IC25.4(A:A2) IC25.6(A:A3) IC25.8(A:A4) IC25.12(A:Y4) IC25.14(A:Y3) IC25.16(A:Y2) IC25.18(A:Y1) IC26.1(A:G) IC26.2(A:A1) IC26.4(A:A2) IC26.6(A:A3) IC26.8(A:A4) IC26.12(A:Y4) IC26.14(A:Y3) IC26.16(A:Y2) IC26.18(A:Y1) IC27.1(A:G) IC27.2(A:A1) IC27.4(A:A2) IC27.6(A:A3) IC27.8(A:A4) IC27.12(A:Y4) IC27.14(A:Y3) IC27.16(A:Y2) IC27.18(A:Y1) IC28.12(Y7) IC28.13(Y6) IC28.14(Y5) IC29.12(Y7) IC29.13(Y6) IC29.14(Y5) IC30.3(B:Y4) IC30.5(B:Y3) IC30.7(B:Y2) IC30.9(B:Y1) IC30.11(B:A1) IC30.13(B:A2) IC30.15(B:A3) IC30.17(B:A4) IC30.19(B:G) IC31.3(B:Y4) IC31.5(B:Y3) IC31.7(B:Y2) IC31.9(B:Y1) IC31.11(B:A1) IC31.13(B:A2) IC31.15(B:A3) IC31.17(B:A4) IC31.19(B:G) IC32.17(D7) IC32.18(D8) IC33.16(Q7) IC33.19(Q8) IC34.1(1G) IC34.15(2G) IC35.1(1G) IC35.15(2G) IC36.1(1G) IC36.15(2G) IC37.1(1G) IC37.15(2G) IC38.1(1G) IC38.15(2G) IC39.4(B:I0) IC39.5(B:I1) IC39.6(B:O) IC39.8(C:O) IC39.9(C:I0) IC39.10(C:I1) IC39.11(D:O) IC39.12(D:I0) IC39.13(D:I1) IC40.1(1G) IC40.15(2G) IC41.1(1G) IC41.15(2G) IC42.4(B:I0) IC42.5(B:I1) IC42.6(B:O) IC42.8(C:O) IC42.9(C:I0) IC42.10(C:I1) IC42.11(D:O) IC42.12(D:I0) IC42.13(D:I1) IC43.1(A:I) IC43.2(A:O) IC43.5(C:I) IC43.6(C:O) IC43.8(D:O) IC43.9(D:I) IC43.10(E:O) IC43.11(E:I) IC43.12(F:O) IC43.13(F:I) IC44.6(A:!Q) IC44.8(B:!Q) IC44.9(B:Q) IC44.10(B:PRE) IC44.11(B:CLK) IC44.12(B:D) IC44.13(B:CLR) IC45.4(B:I0) IC45.5(B:I1) IC45.6(B:O) IC45.8(C:O) IC45.9(C:I0) IC45.10(C:I1) IC45.11(D:O) IC45.12(D:I0) IC45.13(D:I1) IC46.1(A:I0) IC46.2(A:I1) IC46.3(A:O) IC46.8(C:O) IC46.9(C:I0) IC46.10(C:I1) IC46.11(D:O) IC46.12(D:I0) IC46.13(D:I1) IC47.4(B:I0) IC47.5(B:I1) IC47.6(B:O) IC47.8(C:O) IC47.9(C:I0) IC47.10(C:I1) IC47.11(D:O) IC47.12(D:I0) IC47.13(D:I1) IC48.4(2D) IC48.7(3D) IC48.8(4D) IC48.11(CLK) IC48.13(5D) IC48.14(6D) IC48.17(7D) IC49.3(1B) IC49.6(2B) IC49.10(3B) IC49.13(4B) IC50.1(S2) IC50.10(S4) IC50.13(S3) IC51.1(S2) IC51.4(S1) IC51.10(S4) IC51.13(S3) IC52.1(S2) IC52.4(S1) IC52.10(S4) IC52.13(S3) IC53.4(S1) IC53.9(C4) IC53.10(S4) IC53.13(S3) IC54.1(A:I) IC54.2(A:O) IC54.5(C:I) IC54.6(C:O) IC54.8(D:O) IC54.9(D:I) IC54.10(E:O) IC54.11(E:I) IC54.12(F:O) IC54.13(F:I) IC55.3(1B) IC55.6(2B) IC55.10(3B) IC56.9(2Y) IC56.10(2C0) IC56.11(2C1) IC56.12(2C2) IC56.13(2C3) IC57.5(C:I) IC57.6(C:O) IC57.8(D:O) IC57.9(D:I) IC57.10(E:O) IC57.11(E:I) IC57.12(F:O) IC57.13(F:I) IC58.4(B:I0) IC58.5(B:I1) IC58.6(B:O) IC58.8(C:O) IC58.9(C:I0) IC58.10(C:I1) IC58.11(D:O) IC58.12(D:I0) IC58.13(D:I1) IC59.3(B:I) IC59.4(B:O) IC59.5(C:I) IC59.6(C:O) IC59.8(D:O) IC59.9(D:I) IC59.10(E:O) IC59.11(E:I) IC59.12(F:O) IC59.13(F:I) IC60.1(CLR) IC60.9(Q4) IC60.12(Q5) IC60.15(Q6) IC60.16(Q7) IC60.19(Q8) IC61.1(CLR) IC61.2(Q1) IC61.5(Q2) IC61.6(Q3) IC61.9(Q4) IC61.12(Q5) IC61.15(Q6) IC61.16(Q7) IC61.19(Q8) IC62.1(CLR) IC62.2(Q1) IC62.5(Q2) IC62.6(Q3) IC62.9(Q4) IC62.12(Q5) IC62.15(Q6) IC62.16(Q7) IC62.19(Q8) IC64.1(A:I0) IC64.2(A:I1) IC64.8(C:O) IC64.9(C:I0) IC64.10(C:I1) IC64.11(C:I2) IC64.12(A:O) IC64.13(A:I2) IC65.4(B:O) IC65.5(B:I0) IC65.6(B:I1) IC65.8(C:I0) IC65.9(C:I1) IC65.10(C:O) IC65.11(D:I0) IC65.12(D:I1) IC65.13(D:O) IC66.4(B:O) IC66.5(B:I0) IC66.6(B:I1) IC66.8(C:I0) IC66.9(C:I1) IC66.10(C:O) IC66.11(D:I0) IC66.12(D:I1) IC66.13(D:O) IC67.1(A:I0) IC67.2(A:I1) IC67.3(A:O) IC67.8(C:O) IC67.9(C:I0) IC67.10(C:I1) IC67.11(D:O) IC67.12(D:I0) IC67.13(D:I1) IC68.9(3Y) IC68.12(4Y) IC69.1(A:G) IC69.2(A:A1) IC69.3(B:Y4) IC69.4(A:A2) IC69.6(A:A3) IC69.8(A:A4) IC69.12(A:Y4) IC69.14(A:Y3) IC69.16(A:Y2) IC69.18(A:Y1) IC70.6(W) IC72.1(A:I0) IC72.2(A:I1) IC72.3(A:O) IC72.8(C:O) IC72.9(C:I0) IC72.10(C:I1) IC72.11(D:O) IC72.12(D:I0) IC72.13(D:I1) IC74.1(A:I0) IC74.2(A:I1) IC74.3(A:O) IC74.8(C:O) IC74.9(C:I0) IC74.10(C:I1) IC74.11(D:O) IC74.12(D:I0) IC74.13(D:I1) IC75.2(Q1) IC75.5(Q2) IC75.6(Q3) IC75.9(Q4) IC75.12(Q5) IC75.15(Q6) IC75.16(Q7) IC75.19(Q8) IC76.2(Q1) IC77.2(Q1) IC78.2(Q1) IC78.5(Q2) IC78.6(Q3) IC78.9(Q4) IC78.12(Q5) IC78.15(Q6) IC78.16(Q7) IC78.19(Q8) IC79.2(Q1) IC79.5(Q2) IC79.6(Q3) IC79.9(Q4) IC79.12(Q5) IC79.15(Q6) IC79.16(Q7) IC79.19(Q8) IC80.1(A:I0) IC80.2(A:I1) IC80.3(A:O) IC80.8(C:O) IC80.9(C:I0) IC80.10(C:I1) IC80.11(D:O) IC80.12(D:I0) IC80.13(D:I1) IC81.1(A:I0) IC81.2(A:I1) IC81.3(A:O) IC81.8(C:O) IC81.9(C:I0) IC81.10(C:I1) IC81.11(D:O) IC81.12(D:I0) IC81.13(D:I1) IC82.11(CLK) IC83.1(A:I) IC83.2(A:O) IC83.5(C:I) IC83.6(C:O) IC83.8(D:O) IC83.9(D:I) IC83.10(E:O) IC83.11(E:I) IC83.12(F:O) IC83.13(F:I) IC84.1(A:I) IC84.2(A:O) IC84.5(C:I) IC84.6(C:O) IC84.8(D:O) IC84.9(D:I) IC84.10(E:O) IC84.11(E:I) IC84.12(F:O) IC84.13(F:I) IC85.1(A:I0) IC85.2(A:I1) IC85.3(B:I0) IC85.4(B:I1) IC85.5(B:I2) IC85.6(B:O) IC85.8(C:O) IC85.9(C:I0) IC85.10(C:I1) IC85.11(C:I2) IC85.13(A:I2) IC86.11(CLK) IC87.2(A:S1) IC87.5(C:R) IC87.6(C:S) IC87.7(C:Q) IC87.9(B:Q) IC87.10(B:R) IC87.11(B:S1) IC87.12(B:S2) IC87.13(D:Q) IC87.14(D:R) IC87.15(D:S) IC88.11(CLK) IC89.3(B:Y4) IC89.5(B:Y3) IC89.7(B:Y2) IC89.9(B:Y1) IC89.11(B:A1) IC89.13(B:A2) IC89.15(B:A3) IC89.17(B:A4) IC89.19(B:G) IC90.3(B:Y4) IC90.5(B:Y3) IC90.7(B:Y2) IC90.9(B:Y1) IC90.11(B:A1) IC90.13(B:A2) IC90.15(B:A3) IC90.17(B:A4) IC90.19(B:G) IC91.3(B:Y4) IC91.5(B:Y3) IC91.7(B:Y2) IC91.9(B:Y1) IC91.11(B:A1) IC91.13(B:A2) IC91.15(B:A3) IC91.17(B:A4) IC91.19(B:G) IC92.3(B:Y4) IC92.5(B:Y3) IC92.7(B:Y2) IC92.9(B:Y1) IC92.11(B:A1) IC92.13(B:A2) IC92.15(B:A3) IC92.17(B:A4) IC92.19(B:G) IC93.11(CLK) IC98.11(CLK) IC99.11(CLK) IC100.11(CLK) IC101.11(CLK) IC102.12(Y7) IC102.13(Y6) IC102.14(Y5) IC103.12(Y7) IC103.13(Y6) IC103.14(Y5) IC103.15(Y4) IC103.16(Y3) IC103.17(Y2) IC104.12(Y7) IC104.13(Y6) IC104.14(Y5) IC104.15(Y4) IC104.16(Y3) IC104.17(Y2) IC105.1(A:G) IC105.2(A:A1) IC105.4(A:A2) IC105.6(A:A3) IC105.8(A:A4) IC105.12(A:Y4) IC105.14(A:Y3) IC105.16(A:Y2) IC105.18(A:Y1) IC106.1(A:G) IC106.2(A:A1) IC106.4(A:A2) IC106.6(A:A3) IC106.8(A:A4) IC106.12(A:Y4) IC106.14(A:Y3) IC106.16(A:Y2) IC106.18(A:Y1) IC107.1(A:G) IC107.2(A:A1) IC107.4(A:A2) IC107.6(A:A3) IC107.8(A:A4) IC107.12(A:Y4) IC107.14(A:Y3) IC107.16(A:Y2) IC107.18(A:Y1) IC108.1(A:G) IC108.2(A:A1) IC108.4(A:A2) IC108.6(A:A3) IC108.8(A:A4) IC108.12(A:Y4) IC108.14(A:Y3) IC108.16(A:Y2) IC108.18(A:Y1) IC109.1(A:G) IC109.2(A:A1) IC109.4(A:A2) IC109.6(A:A3) IC109.8(A:A4) IC109.12(A:Y4) IC109.14(A:Y3) IC109.16(A:Y2) IC109.18(A:Y1) IC110.1(A:G) IC110.2(A:A1) IC110.4(A:A2) IC110.6(A:A3) IC110.8(A:A4) IC110.12(A:Y4) IC110.14(A:Y3) IC110.16(A:Y2) IC110.18(A:Y1) IC111.1(A:G) IC111.2(A:A1) IC111.4(A:A2) IC111.6(A:A3) IC111.8(A:A4) IC111.12(A:Y4) IC111.14(A:Y3) IC111.16(A:Y2) IC111.18(A:Y1) IC112.1(A:G) IC112.2(A:A1) IC112.4(A:A2) IC112.6(A:A3) IC112.8(A:A4) IC112.12(A:Y4) IC112.14(A:Y3) IC112.16(A:Y2) IC112.18(A:Y1) IC113.13(Y6) IC113.14(Y5) IC113.19(G2) IC114.13(Y6) IC114.14(Y5) IC114.19(G2) IC115.13(Y6) IC115.14(Y5) IC117.12(Y7) IC117.13(Y6) IC117.14(Y5) IC118.1(G1) IC118.11(Y8) IC118.12(Y7) IC118.19(G2) IC119.1(A:I) IC119.2(A:O) IC119.5(C:I) IC119.6(C:O) IC119.8(D:O) IC119.9(D:I) IC119.10(E:O) IC119.11(E:I) IC119.12(F:O) IC119.13(F:I) IC120.4(B:I0) IC120.5(B:I1) IC120.6(B:O) IC120.8(C:O) IC120.9(C:I0) IC120.10(C:I1) IC120.11(D:O) IC120.12(D:I0) IC120.13(D:I1) IC121.4(1Y) IC121.5(2A) IC121.6(2B) IC121.7(2Y) IC121.9(3Y) IC121.10(3B) IC121.11(3A) IC121.12(4Y) IC121.13(4B) IC121.14(4A) IC122.12(Y7) IC122.13(Y6) IC122.14(Y5) IC123.11(CLK) IC123.18(8D) IC124.4(B:I0) IC124.5(B:I1) IC124.6(B:O) IC124.8(C:O) IC124.9(C:I0) IC124.10(C:I1) IC124.11(D:O) IC124.12(D:I0) IC124.13(D:I1) IC126.11(CLK) IC126.12(5Q) IC126.13(5D) IC126.14(6D) IC126.15(6Q) IC126.16(7Q) IC126.17(7D) IC126.18(8D) IC126.19(8Q) IC127.4(B:I0) IC127.5(B:I1) IC127.6(B:O) IC127.8(C:O) IC127.9(C:I0) IC127.10(C:I1) IC127.11(D:O) IC127.12(D:I0) IC127.13(D:I1) IC130.1(A:I0) IC130.2(A:I1) IC130.3(A:O) IC130.8(C:O) IC130.9(C:I0) IC130.10(C:I1) IC130.11(D:O) IC130.12(D:I0) IC130.13(D:I1) IC131.4(B:O) IC131.5(B:I0) IC131.6(B:I1) IC131.8(C:I0) IC131.9(C:I1) IC131.10(C:O) IC131.11(D:I0) IC131.12(D:I1) IC131.13(D:O) IC132.1(A:I0) IC132.2(A:I1) IC132.8(C:O) IC132.9(C:I0) IC132.10(C:I1) IC132.11(C:I2) IC132.12(A:O) IC132.13(A:I2) IC133.3(A:O) IC133.4(B:I0) IC133.5(B:I1) IC133.6(B:O) IC133.8(C:O) IC133.9(C:I0) IC133.10(C:I1) IC133.11(D:O) IC133.12(D:I0) IC133.13(D:I1) IC134.2(Q1) IC134.5(Q2) IC134.6(Q3) IC134.9(Q4) IC134.12(Q5) IC134.15(Q6) IC134.16(Q7) IC134.19(Q8) IC135.2(Q1) IC135.5(Q2) IC135.6(Q3) IC135.9(Q4) IC135.12(Q5) IC135.15(Q6) IC135.16(Q7) IC135.19(Q8) IC136.2(Q1) IC136.5(Q2) IC136.6(Q3) IC136.9(Q4) IC136.12(Q5) IC136.15(Q6) IC136.16(Q7) IC136.19(Q8) IC137.2(Q1) IC137.5(Q2) IC137.6(Q3) IC137.9(Q4) IC137.12(Q5) IC137.15(Q6) IC137.16(Q7) IC137.19(Q8) IC138.3(B:I0) IC138.4(B:I1) IC138.5(B:I2) IC138.6(B:O) IC138.8(C:O) IC138.9(C:I0) IC138.10(C:I1) IC138.11(C:I2) IC139.4(Q2) IC139.5(Q3) IC139.6(Q4) IC139.11(D4) IC139.12(D3) IC139.13(D2) IC140.1(G1) IC140.19(G2) IC141.3(B:I0) IC141.4(B:I1) IC141.5(B:I2) IC141.6(B:O) IC141.8(C:O) IC141.9(C:I0) IC141.10(C:I1) IC141.11(C:I2) IC143.4(B:I0) IC143.5(B:I1) IC143.6(B:O) IC143.8(C:O) IC143.9(C:I0) IC143.10(C:I1) IC143.11(D:O) IC143.12(D:I0) IC143.13(D:I1) IC145.12(Y7) IC145.13(Y6) IC145.14(Y5) IC146.12(Y7) IC146.13(Y6) IC146.14(Y5) IC147.1(A:I0) IC147.2(A:I1) IC147.3(A:O) IC147.8(C:O) IC147.9(C:I0) IC147.10(C:I1) IC147.11(D:O) IC147.12(D:I0) IC147.13(D:I1) IC148.1(A:I) IC148.2(A:O) IC148.5(C:I) IC148.6(C:O) IC148.8(D:O) IC148.9(D:I) IC148.10(E:O) IC148.11(E:I) IC148.12(F:O) IC148.13(F:I) IC149.1(A:I) IC149.2(A:O) IC149.5(C:I) IC149.6(C:O) IC149.8(D:O) IC149.9(D:I) IC149.10(E:O) IC149.11(E:I) IC149.12(F:O) IC149.13(F:I) IC150.1(A:I0) IC150.2(A:I1) IC150.8(C:O) IC150.9(C:I0) IC150.10(C:I1) IC150.11(C:I2) IC150.12(A:O) IC150.13(A:I2) IC151.1(A:I0) IC151.2(A:I1) IC151.8(C:O) IC151.9(C:I0) IC151.10(C:I1) IC151.11(C:I2) IC151.12(A:O) IC151.13(A:I2) IC152.1(A:I0) IC152.2(A:I1) IC152.3(A:O) IC152.4(B:I0) IC152.5(B:I1) IC152.6(B:O) IC152.11(D:O) IC152.12(D:I0) IC152.13(D:I1) IC153.11(CLK) IC155.3(1C3) IC155.5(1C1) IC155.6(1C0) IC155.10(2C0) IC155.11(2C1) IC155.13(2C3) IC156.3(1C3) IC156.5(1C1) IC156.6(1C0) IC156.10(2C0) IC156.11(2C1) IC156.13(2C3) IC157.1(A:I0) IC157.2(A:I1) IC157.8(C:O) IC157.9(C:I0) IC157.10(C:I1) IC157.11(C:I2) IC157.12(A:O) IC157.13(A:I2) IC158.1(A:I0) IC158.2(A:I1) IC158.8(C:O) IC158.9(C:I0) IC158.10(C:I1) IC158.11(C:I2) IC158.12(A:O) IC158.13(A:I2) IC161.4(B:I0) IC161.5(B:I1) IC161.6(B:O) IC161.8(C:O) IC161.9(C:I0) IC161.10(C:I1) IC161.11(D:O) IC161.12(D:I0) IC161.13(D:I1) IC163.6(A:!Q) IC163.8(B:!Q) IC163.9(B:Q) IC163.10(B:PRE) IC163.11(B:CLK) IC163.12(B:D) IC163.13(B:CLR) IC164.6(A:!Q) IC164.8(B:!Q) IC164.9(B:Q) IC164.10(B:PRE) IC164.11(B:CLK) IC164.12(B:D) IC164.13(B:CLR) IC165.1(G1) IC165.2(A1) IC165.3(A2) IC165.4(A3) IC165.5(A4) IC165.6(A5) IC165.7(A6) IC165.8(A7) IC165.9(A8) IC165.11(Y8) IC165.12(Y7) IC165.14(Y5) IC165.15(Y4) IC165.16(Y3) IC165.17(Y2) IC165.18(Y1) IC165.19(G2) IC166.1(G1) IC166.4(A3) IC166.5(A4) IC166.6(A5) IC166.7(A6) IC166.8(A7) IC166.9(A8) IC166.11(Y8) IC166.12(Y7) IC166.13(Y6) IC166.14(Y5) IC166.15(Y4) IC166.16(Y3) IC166.19(G2) IC167.5(2A) IC167.6(2B) IC167.7(2Y) IC167.9(3Y) IC167.10(3B) IC167.11(3A) IC167.12(4Y) IC167.13(4B) IC167.14(4A) IC168.6(A:!Q) IC168.8(B:!Q) IC168.9(B:Q) IC168.10(B:PRE) IC168.11(B:CLK) IC168.12(B:D) IC168.13(B:CLR) IC169.15(G) IC170.1(A:I0) IC170.2(A:I1) IC170.3(A:O) IC170.8(C:O) IC170.9(C:I0) IC170.10(C:I1) IC170.11(D:O) IC170.12(D:I0) IC170.13(D:I1) IC171.15(G) IC172.9(3Y) IC172.12(4Y) IC172.15(G) IC173.15(G) IC174.6(A:!Q) IC174.8(B:!Q) IC174.9(B:Q) IC174.10(B:PRE) IC174.11(B:CLK) IC174.12(B:D) IC174.13(B:CLR) IC175.1(A:I0) IC175.2(A:I1) IC175.3(A:O) IC175.8(C:O) IC175.9(C:I0) IC175.10(C:I1) IC175.11(D:O) IC175.12(D:I0) IC175.13(D:I1) IC176.3(B:Y4) IC176.5(B:Y3) IC176.7(B:Y2) IC176.9(B:Y1) IC176.11(B:A1) IC176.13(B:A2) IC176.15(B:A3) IC176.17(B:A4) IC176.19(B:G) IC177.1(A:I0) IC177.2(A:I1) IC177.3(A:O) IC177.8(C:O) IC177.9(C:I0) IC177.10(C:I1) IC177.11(D:O) IC177.12(D:I0) IC177.13(D:I1) IC178.3(B:Y4) IC178.5(B:Y3) IC178.7(B:Y2) IC178.9(B:Y1) IC178.11(B:A1) IC178.13(B:A2) IC178.15(B:A3) IC178.17(B:A4) IC178.19(B:G) IC179.3(B:Y4) IC179.5(B:Y3) IC179.7(B:Y2) IC179.9(B:Y1) IC179.11(B:A1) IC179.13(B:A2) IC179.15(B:A3) IC179.17(B:A4) IC179.19(B:G) IC180.11(CLK) IC181.3(B:Y4) IC181.5(B:Y3) IC181.7(B:Y2) IC181.9(B:Y1) IC181.11(B:A1) IC181.13(B:A2) IC181.15(B:A3) IC181.17(B:A4) IC181.19(B:G) IC182.3(B:Y4) IC182.5(B:Y3) IC182.7(B:Y2) IC182.9(B:Y1) IC182.11(B:A1) IC182.13(B:A2) IC182.15(B:A3) IC182.17(B:A4) IC182.19(B:G) IC183.3(B:Y4) IC183.5(B:Y3) IC183.7(B:Y2) IC183.9(B:Y1) IC183.11(B:A1) IC183.13(B:A2) IC183.15(B:A3) IC183.17(B:A4) IC183.19(B:G) IC184.11(CLK) IC185.11(CLK) IC187.6(A:!Q) IC187.8(B:!Q) IC187.9(B:Q) IC187.10(B:PRE) IC187.11(B:CLK) IC187.12(B:D) IC187.13(B:CLR) IC188.6(A:!Q) IC188.8(B:!Q) IC188.9(B:Q) IC188.10(B:PRE) IC188.11(B:CLK) IC188.12(B:D) IC188.13(B:CLR) IC189.4(2D) IC189.7(3D) IC189.8(4D) IC189.13(5D) IC189.14(6D) IC189.17(7D) IC190.1(A:I0) IC190.2(A:I1) IC190.3(A:O) IC190.4(B:I0) IC190.5(B:I1) IC190.6(B:O) IC190.11(D:O) IC190.12(D:I0) IC190.13(D:I1) IC191.1(A:I0) IC191.2(A:I1) IC191.8(C:O) IC191.9(C:I0) IC191.10(C:I1) IC191.11(C:I2) IC191.12(A:O) IC191.13(A:I2) IC192.1(A:I0) IC192.2(A:I1) IC192.3(A:O) IC192.8(C:O) IC192.9(C:I0) IC192.10(C:I1) IC192.11(D:O) IC192.12(D:I0) IC192.13(D:I1) IC193.1(A:I0) IC193.2(A:I1) IC193.3(A:O) IC193.8(C:O) IC193.9(C:I0) IC193.10(C:I1) IC193.11(D:O) IC193.12(D:I0) IC193.13(D:I1) IC194.1(A:I0) IC194.2(A:I1) IC194.3(A:O) IC194.8(C:O) IC194.9(C:I0) IC194.10(C:I1) IC194.11(D:O) IC194.12(D:I0) IC194.13(D:I1) IC197.4(B:I0) IC197.6(B:O) IC197.8(B:I1) IC197.9(B:I2) IC197.10(B:I3) IC197.11(B:I4) IC198.3(B:I) IC198.4(B:O) IC198.5(C:I) IC198.6(C:O) IC198.8(D:O) IC198.9(D:I) IC198.10(E:O) IC198.11(E:I) IC198.12(F:O) IC198.13(F:I) IC199.4(B:I0) IC199.6(B:O) IC199.8(B:I1) IC199.9(B:I2) IC199.10(B:I3) IC199.11(B:I4) IC200.1(A:I0) IC200.2(A:I1) IC200.3(A:O) IC200.8(C:O) IC200.9(C:I0) IC200.10(C:I1) IC200.11(D:O) IC200.12(D:I0) IC200.13(D:I1) IC201.1(A:I0) IC201.2(A:I1) IC201.3(A:O) IC201.4(B:I0) IC201.5(B:I1) IC201.6(B:O) IC201.11(D:O) IC201.12(D:I0) IC201.13(D:I1) IC202.4(B:I0) IC202.5(B:I1) IC202.6(B:O) IC202.8(C:O) IC202.9(C:I0) IC202.10(C:I1) IC202.11(D:O) IC202.12(D:I0) IC202.13(D:I1) IC203.1(A:I0) IC203.2(A:I1) IC203.3(A:O) IC203.4(B:I0) IC203.5(B:I1) IC203.6(B:O) IC203.11(D:O) IC203.12(D:I0) IC203.13(D:I1) IC206.1(A:I0) IC206.2(A:I1) IC206.3(A:O) IC206.4(B:I0) IC206.5(B:I1) IC206.6(B:O) IC206.11(D:O) IC206.12(D:I0) IC206.13(D:I1) IC207.4(B:I0) IC207.5(B:I1) IC207.6(B:O) IC207.8(C:O) IC207.9(C:I0) IC207.10(C:I1) IC207.11(D:O) IC207.12(D:I0) IC207.13(D:I1) IC208.1(1G) IC208.9(2Y) IC208.10(2C0) IC208.11(2C1) IC208.12(2C2) IC208.13(2C3) IC208.15(2G) IC209.1(A:I0) IC209.2(A:I1) IC209.3(A:O) IC209.8(C:O) IC209.9(C:I0) IC209.10(C:I1) IC209.11(D:O) IC209.12(D:I0) IC209.13(D:I1) IC211.3(B:Y4) IC211.5(B:Y3) IC211.7(B:Y2) IC211.9(B:Y1) IC211.11(B:A1) IC211.13(B:A2) IC211.15(B:A3) IC211.17(B:A4) IC211.19(B:G) IC212.3(B:Y4) IC212.5(B:Y3) IC212.7(B:Y2) IC212.9(B:Y1) IC212.11(B:A1) IC212.13(B:A2) IC212.15(B:A3) IC212.17(B:A4) IC212.19(B:G) IC213.3(B:Y4) IC213.5(B:Y3) IC213.7(B:Y2) IC213.9(B:Y1) IC213.11(B:A1) IC213.13(B:A2) IC213.15(B:A3) IC213.17(B:A4) IC213.19(B:G) IC214.3(B:Y4) IC214.5(B:Y3) IC214.7(B:Y2) IC214.9(B:Y1) IC214.11(B:A1) IC214.13(B:A2) IC214.15(B:A3) IC214.17(B:A4) IC214.19(B:G) IC216.1(G) IC216.11(CLK) IC218.4(B:I0) IC218.5(B:I1) IC218.6(B:O) IC218.8(C:O) IC218.9(C:I0) IC218.10(C:I1) IC218.11(D:O) IC218.12(D:I0) IC218.13(D:I1) IC219.4(B:I0) IC219.5(B:I1) IC219.6(B:O) IC219.8(C:O) IC219.9(C:I0) IC219.10(C:I1) IC219.11(D:O) IC219.12(D:I0) IC219.13(D:I1) IC220.4(B:I0) IC220.5(B:I1) IC220.6(B:O) IC220.8(C:O) IC220.9(C:I0) IC220.10(C:I1) IC220.11(D:O) IC220.12(D:I0) IC220.13(D:I1) IC221.6(A:!Q) IC221.8(B:!Q) IC221.9(B:Q) IC221.10(B:PRE) IC221.11(B:CLK) IC221.12(B:D) IC221.13(B:CLR) IC222.15(Y0) IC223.4(B:I0) IC223.5(B:I1) IC223.6(B:O) IC223.8(C:O) IC223.9(C:I0) IC223.10(C:I1) IC223.11(D:O) IC223.12(D:I0) IC223.13(D:I1) IC224.4(B:I0) IC224.5(B:I1) IC224.6(B:O) IC224.8(C:O) IC224.9(C:I0) IC224.10(C:I1) IC224.11(D:O) IC224.12(D:I0) IC224.13(D:I1) IC225.4(B:I0) IC225.5(B:I1) IC225.6(B:O) IC225.8(C:O) IC225.9(C:I0) IC225.10(C:I1) IC225.11(D:O) IC225.12(D:I0) IC225.13(D:I1) IC227.11(CLK) IC228.1(A:I0) IC228.2(A:I1) IC228.3(A:O) IC228.4(B:I0) IC228.5(B:I1) IC228.6(B:O) IC228.11(D:O) IC228.12(D:I0) IC228.13(D:I1) IC229.3(B:Y4) IC229.5(B:Y3) IC229.7(B:Y2) IC229.9(B:Y1) IC229.11(B:A1) IC229.13(B:A2) IC229.15(B:A3) IC229.17(B:A4) IC229.19(B:G) IC230.3(B:Y4) IC230.5(B:Y3) IC230.7(B:Y2) IC230.9(B:Y1) IC230.11(B:A1) IC230.13(B:A2) IC230.15(B:A3) IC230.17(B:A4) IC230.19(B:G) IC231.3(B:Y4) IC231.5(B:Y3) IC231.7(B:Y2) IC231.9(B:Y1) IC231.11(B:A1) IC231.13(B:A2) IC231.15(B:A3) IC231.17(B:A4) IC231.19(B:G) IC232.3(B:Y4) IC232.5(B:Y3) IC232.7(B:Y2) IC232.9(B:Y1) IC232.11(B:A1) IC232.13(B:A2) IC232.15(B:A3) IC232.17(B:A4) IC232.19(B:G) IC233.11(CLK) IC234.11(CLK) IC235.3(B:Y4) IC235.5(B:Y3) IC235.7(B:Y2) IC235.9(B:Y1) IC235.11(B:A1) IC235.13(B:A2) IC235.15(B:A3) IC235.17(B:A4) IC235.19(B:G) IC236.3(B:Y4) IC236.5(B:Y3) IC236.7(B:Y2) IC236.9(B:Y1) IC236.11(B:A1) IC236.13(B:A2) IC236.15(B:A3) IC236.17(B:A4) IC236.19(B:G) IC237.3(B:Y4) IC237.5(B:Y3) IC237.7(B:Y2) IC237.9(B:Y1) IC237.11(B:A1) IC237.13(B:A2) IC237.15(B:A3) IC237.17(B:A4) IC237.19(B:G) IC238.3(B:Y4) IC238.5(B:Y3) IC238.7(B:Y2) IC238.9(B:Y1) IC238.11(B:A1) IC238.13(B:A2) IC238.15(B:A3) IC238.17(B:A4) IC238.19(B:G) IC239.11(CLK) IC240.11(CLK) IC241.1(1G) IC241.9(2Y) IC241.10(2C0) IC241.11(2C1) IC241.12(2C2) IC241.13(2C3) IC241.15(2G) IC242.1(A:I0) IC242.2(A:I1) IC242.3(A:O) IC242.4(B:I0) IC242.5(B:I1) IC242.6(B:O) IC242.11(D:O) IC242.12(D:I0) IC242.13(D:I1) IC243.1(1G) IC243.9(2Y) IC243.10(2C0) IC243.11(2C1) IC243.12(2C2) IC243.13(2C3) IC243.15(2G) IC244.1(A:G) IC244.2(A:A1) IC244.4(A:A2) IC244.5(B:Y3) IC244.6(A:A3) IC244.7(B:Y2) IC244.8(A:A4) IC244.12(A:Y4) IC244.14(A:Y3) IC244.16(A:Y2) IC244.18(A:Y1) IC247.1(A:G) IC247.2(A:A1) IC247.4(A:A2) IC247.5(B:Y3) IC247.6(A:A3) IC247.7(B:Y2) IC247.8(A:A4) IC247.12(A:Y4) IC247.14(A:Y3) IC247.16(A:Y2) IC247.18(A:Y1) IC250.1(A:I0) IC250.2(A:I1) IC250.3(A:O) IC250.8(C:O) IC250.9(C:I0) IC250.10(C:I1) IC250.11(D:O) IC250.12(D:I0) IC250.13(D:I1) IC251.6(A:!Q) IC251.8(B:!Q) IC251.9(B:Q) IC251.10(B:PRE) IC251.11(B:CLK) IC251.12(B:D) IC251.13(B:CLR) IC252.4(B:I0) IC252.5(B:I1) IC252.6(B:O) IC252.8(C:O) IC252.9(C:I0) IC252.10(C:I1) IC252.11(D:O) IC252.12(D:I0) IC252.13(D:I1) IC253.4(B:I0) IC253.5(B:I1) IC253.6(B:O) IC253.8(C:O) IC253.9(C:I0) IC253.10(C:I1) IC253.11(D:O) IC253.12(D:I0) IC253.13(D:I1) IC254.1(A:I) IC254.2(A:O) IC254.5(C:I) IC254.6(C:O) IC254.8(D:O) IC254.9(D:I) IC254.10(E:O) IC254.11(E:I) IC254.12(F:O) IC254.13(F:I) IC255.1(1G) IC255.9(2Y) IC255.10(2C0) IC255.11(2C1) IC255.12(2C2) IC255.13(2C3) IC255.15(2G) IC256.1(1G) IC256.9(2Y) IC256.10(2C0) IC256.11(2C1) IC256.12(2C2) IC256.13(2C3) IC256.15(2G) IC257.15(G) RN4.4 RN4.5 RN4.6 RN4.7 RN4.8 RN4.9 RN4.10 RN4.11 RN4.12 RN4.13 S2.1(O) S4.1(O) SW3.8 U$1.28(VCC) U$2.28(VCC) U$3.28(VCC) U$4.28(VCC) U$5.28(VCC) U$6.28(VCC) U$7.28(VCC) U$8.28(VCC) U$9.28(VCC) U$10.1(A14) U$10.2(A12) U$10.3(A7) U$10.4(A6) U$10.5(A5) U$10.6(A4) U$10.7(A3) U$10.8(A2) U$10.9(A1) U$10.10(A0) U$10.14(GND) U$10.20(/CE) U$10.21(A10) U$10.22(/OE) U$10.23(A11) U$10.24(A9) U$10.25(A8) U$10.26(A13) U$10.27(/WE) U$10.28(VCC) U$11.1(A14) U$11.2(A12) U$11.3(A7) U$11.4(A6) U$11.5(A5) U$11.6(A4) U$11.7(A3) U$11.8(A2) U$11.9(A1) U$11.10(A0) U$11.14(GND) U$11.20(/CE) U$11.21(A10) U$11.22(/OE) U$11.23(A11) U$11.24(A9) U$11.25(A8) U$11.26(A13) U$11.27(/WE) U$11.28(VCC) U$12.1(A14) U$12.2(A12) U$12.3(A7) U$12.4(A6) U$12.5(A5) U$12.6(A4) U$12.7(A3) U$12.8(A2) U$12.9(A1) U$12.10(A0) U$12.14(GND) U$12.20(/CE) U$12.21(A10) U$12.22(/OE) U$12.23(A11) U$12.24(A9) U$12.25(A8) U$12.26(A13) U$12.27(/WE) U$12.28(VCC)

## Buses
XBUS[0..7]
ZBUS[0..7]
YBUS[0..7]
AD[0..15]
MDR_IN_BUS[0..7]
U_AD[0..13]
DATA[0..7]
U_AD_BUFF[0..13]
Z_BUS[0..7]
U_ADDR_BUFF1_[0..13]

## Notes on the sheet
- R_SHIFT_L
- SINGLE STEP CLOCK
- fast clock
- slow clock
- SYNCHRONIZED INTERRUPT INPUTS
- DMA_REQ
  INT_REQ_0
  INT_REQ_1
  INT_REQ_2
  INT_REQ_3
  INT_REQ_4
  INT_REQ_5
  INT_REQ_6
- R_SHIFT_H
- might need to flip flop this output in case it oscillates
- IMMX
- TDR0_L
- dma = 000
  
  there will be a hole in memory in the interrupt
  vector because dma is has no actual code in ram
  
  CORRECTION: HOLE WILL BE FILLED BY TRAP CODE
- the encoded bits start at position 3 in the byte. 
  this is so it's easier to just transfer this to PC and 
  have it become the interrupt vector in memory.
  
  so each interrupt spans 8 bytes in memory.
  
  DMA starts at 0 and has no respective code.
  the DMA code is taken by the TRAP interrupt.
  the other interrupts start at address 8 onwards.
- TDR0_H
- 00000000 = dma (taken by trap)
  00001000 = int_0
  00010000 = int_1
  00011000 = int_2
  etc
- TDR1_L
- TDR1_H
- MASK_FLAGS
- U-ADDRESS MUX
- OFFSET(6)
- AL
- Z BUS
- PC_L
- U-CODE ROMS
- U-ADDRESS
- IR | U-CODE FF'S
- AH
- ADDRESS & DATA BUSES NEED PULL DOWN RESISTORS 
  BECAUSE THE CPU BUS OUTPUTS HAVE 
  244'S WHICH ARE CLOSED MOST OF THE TIME.
- LOW | ADDRESS BUS | PC_H
- MARL
- LOW
- ADDER
- BL
- HIGH
- SP_L
- BH
- ADDER
- MARH
- MAR is tri-stated when in programming or DMA mode. | SP_H
- programming mode signal goes here to tell MAR to go tristate
- AUX_FLAGS
- CL
- BP_L
- CH
- if type = branch, and condition = false, then next = +1
- HIGH
- BP_H
- DL
- U-ADDRESS MUX
- Z BUS
- MUX1
- FLAGS REGISTER
- DH
- U_FLAGS
- CONDITION SOURCE
  PROGRAMMER'S FLAGS 
  OR
  U_CODE FLAGS
- CARRY IN MUX
- ZF
- BUS GOING INTO MDR INPUTS
- CF / LTU
- SF
- OF
- PF
- X BUS
- DATA BUS
- MDR_L
- LT
  LTE
  ~LT = GTE
  ~LTE + GT
- MDR MUX | MDR_H
- BUS GOING INTO MDR INPUTS
- IMMY
- ALU
- alu_mode removed. OF is undefined if alu in logic mode anyway. | alu_op == add
- DATA BUS
- SERIES TERMINATION ~80 ohm
- ALU_OP == SUB
- TDR0_L
- IMMY
- TDR0_H
- FROM MICROCODE
- TDR1_L
- TDR1_H
- THESE TDR'S ARE THE SAME ONES AS ARE CONNECTED TO THE X BUS

## Power pins joined to a net without a drawn wire
GND: IC1.10(GND) IC2.10(GND) IC3.10(GND) IC4.10(GND) IC5.10(GND) IC6.10(GND) IC7.10(GND) IC9.10(GND) IC10.10(P:GND) IC11.10(P:GND) IC12.10(P:GND) IC13.10(P:GND) IC14.12(GND) IC15.12(GND) IC16.10(GND) IC17.10(GND) IC18.7(P:GND) IC19.10(GND) IC20.10(GND) IC21.10(GND) IC22.8(GND) IC23.8(GND) IC24.10(P:GND) IC25.10(P:GND) IC26.10(P:GND) IC27.10(P:GND) IC28.10(GND) IC29.10(GND) IC30.10(P:GND) IC31.10(P:GND) IC32.10(GND) IC33.10(GND) IC34.8(GND) IC35.8(GND) IC36.8(GND) IC37.8(GND) IC38.8(GND) IC39.7(P:GND) IC40.8(GND) IC41.8(GND) IC42.7(P:GND) IC43.7(P:GND) IC44.7(P:GND) IC45.7(P:GND) IC46.7(P:GND) IC47.7(P:GND) IC48.10(GND) IC49.8(GND) IC50.8(GND) IC51.8(GND) IC52.8(GND) IC53.8(GND) IC54.7(P:GND) IC55.8(GND) IC56.8(GND) IC57.7(P:GND) IC58.7(P:GND) IC59.7(P:GND) IC60.10(GND) IC61.10(GND) IC62.10(GND) IC63.8(GND) IC64.7(P:GND) IC65.7(P:GND) IC66.7(P:GND) IC67.7(P:GND) IC68.8(GND) IC69.10(P:GND) IC70.8(GND) IC72.7(P:GND) IC74.7(P:GND) IC75.10(GND) IC76.10(GND) IC77.10(GND) IC78.10(GND) IC79.10(GND) IC80.7(P:GND) IC81.7(P:GND) IC82.10(GND) IC83.7(P:GND) IC84.7(P:GND) IC85.7(P:GND) IC86.10(GND) IC87.8(P:GND) IC88.10(GND) IC89.10(P:GND) IC90.10(P:GND) IC91.10(P:GND) IC92.10(P:GND) IC93.10(GND) IC94.8(GND) IC95.8(GND) IC96.8(GND) IC97.8(GND) IC98.10(GND) IC99.10(GND) IC100.10(GND) IC101.10(GND) IC102.10(GND) IC103.10(GND) IC104.10(GND) IC105.10(P:GND) IC106.10(P:GND) IC107.10(P:GND) IC108.10(P:GND) IC109.10(P:GND) IC110.10(P:GND) IC111.10(P:GND) IC112.10(P:GND) IC113.10(GND) IC114.10(GND) IC115.10(GND) IC116.10(GND) IC117.10(GND) IC118.10(GND) IC119.7(P:GND) IC120.7(P:GND) IC121.8(GND) IC122.10(GND) IC123.10(GND) IC124.7(P:GND) IC125.10(GND) IC126.10(GND) IC127.7(P:GND) IC128.8(GND) IC130.7(P:GND) IC131.7(P:GND) IC132.7(P:GND) IC133.7(P:GND) IC134.10(GND) IC135.10(GND) IC136.10(GND) IC137.10(GND) IC138.7(P:GND) IC139.8(GND) IC140.10(GND) IC141.7(P:GND) IC143.7(P:GND) IC144.8(GND) IC145.10(GND) IC146.10(GND) IC147.7(P:GND) IC148.7(P:GND) IC149.7(P:GND) IC150.7(P:GND) IC151.7(P:GND) IC152.7(P:GND) IC153.10(GND) IC154.10(GND) IC155.8(GND) IC156.8(GND) IC157.7(P:GND) IC158.7(P:GND) IC161.7(P:GND) IC162.10(GND) IC163.7(P:GND) IC164.7(P:GND) IC165.10(GND) IC166.10(GND) IC167.8(GND) IC168.7(P:GND) IC169.8(GND) IC170.7(P:GND) IC171.8(GND) IC172.8(GND) IC173.8(GND) IC174.7(P:GND) IC175.7(P:GND) IC176.10(P:GND) IC177.7(P:GND) IC178.10(P:GND) IC179.10(P:GND) IC180.10(GND) IC181.10(P:GND) IC182.10(P:GND) IC183.10(P:GND) IC184.10(GND) IC185.10(GND) IC187.7(P:GND) IC188.7(P:GND) IC189.10(GND) IC190.7(P:GND) IC191.7(P:GND) IC192.7(P:GND) IC193.7(P:GND) IC194.7(P:GND) IC197.7(P:GND) IC198.7(P:GND) IC199.7(P:GND) IC200.7(P:GND) IC201.7(P:GND) IC202.7(P:GND) IC203.7(P:GND) IC206.7(P:GND) IC207.7(P:GND) IC208.8(GND) IC209.7(P:GND) IC211.10(P:GND) IC212.10(P:GND) IC213.10(P:GND) IC214.10(P:GND) IC216.10(GND) IC218.7(P:GND) IC219.7(P:GND) IC220.7(P:GND) IC221.7(P:GND) IC222.8(GND) IC223.7(P:GND) IC224.7(P:GND) IC225.7(P:GND) IC226.8(GND) IC227.10(GND) IC228.7(P:GND) IC229.10(P:GND) IC230.10(P:GND) IC231.10(P:GND) IC232.10(P:GND) IC233.10(GND) IC234.10(GND) IC235.10(P:GND) IC236.10(P:GND) IC237.10(P:GND) IC238.10(P:GND) IC239.10(GND) IC240.10(GND) IC241.8(GND) IC242.7(P:GND) IC243.8(GND) IC244.10(P:GND) IC245.10(GND) IC247.10(P:GND) IC248.8(GND) IC249.8(GND) IC250.7(P:GND) IC251.7(P:GND) IC252.7(P:GND) IC253.7(P:GND) IC254.7(P:GND) IC255.8(GND) IC256.8(GND) IC257.8(GND) IC258.8(GND)
VCC: IC1.20(VCC) IC2.20(VCC) IC3.20(VCC) IC4.20(VCC) IC5.20(VCC) IC6.20(VCC) IC7.20(VCC) IC9.20(VCC) IC10.20(P:VCC) IC11.20(P:VCC) IC12.20(P:VCC) IC13.20(P:VCC) IC14.24(VCC) IC15.24(VCC) IC16.20(VCC) IC17.20(VCC) IC18.14(P:VCC) IC19.20(VCC) IC20.20(VCC) IC21.20(VCC) IC22.16(VCC) IC23.16(VCC) IC24.20(P:VCC) IC25.20(P:VCC) IC26.20(P:VCC) IC27.20(P:VCC) IC28.20(VCC) IC29.20(VCC) IC30.20(P:VCC) IC31.20(P:VCC) IC32.20(VCC) IC33.20(VCC) IC34.16(VCC) IC35.16(VCC) IC36.16(VCC) IC37.16(VCC) IC38.16(VCC) IC39.14(P:VCC) IC40.16(VCC) IC41.16(VCC) IC42.14(P:VCC) IC43.14(P:VCC) IC44.14(P:VCC) IC45.14(P:VCC) IC46.14(P:VCC) IC47.14(P:VCC) IC48.20(VCC) IC49.16(VCC) IC50.16(VCC) IC51.16(VCC) IC52.16(VCC) IC53.16(VCC) IC54.14(P:VCC) IC55.16(VCC) IC56.16(VCC) IC57.14(P:VCC) IC58.14(P:VCC) IC59.14(P:VCC) IC60.20(VCC) IC61.20(VCC) IC62.20(VCC) IC63.16(VCC) IC64.14(P:VCC) IC65.14(P:VCC) IC66.14(P:VCC) IC67.14(P:VCC) IC68.16(VCC) IC69.20(P:VCC) IC70.16(VCC) IC72.14(P:VCC) IC74.14(P:VCC) IC75.20(VCC) IC76.20(VCC) IC77.20(VCC) IC78.20(VCC) IC79.20(VCC) IC80.14(P:VCC) IC81.14(P:VCC) IC82.20(VCC) IC83.14(P:VCC) IC84.14(P:VCC) IC85.14(P:VCC) IC86.20(VCC) IC87.16(P:VCC) IC88.20(VCC) IC89.20(P:VCC) IC90.20(P:VCC) IC91.20(P:VCC) IC92.20(P:VCC) IC93.20(VCC) IC94.16(VCC) IC95.16(VCC) IC96.16(VCC) IC97.16(VCC) IC98.20(VCC) IC99.20(VCC) IC100.20(VCC) IC101.20(VCC) IC102.20(VCC) IC103.20(VCC) IC104.20(VCC) IC105.20(P:VCC) IC106.20(P:VCC) IC107.20(P:VCC) IC108.20(P:VCC) IC109.20(P:VCC) IC110.20(P:VCC) IC111.20(P:VCC) IC112.20(P:VCC) IC113.20(VCC) IC114.20(VCC) IC115.20(VCC) IC116.20(VCC) IC117.20(VCC) IC118.20(VCC) IC119.14(P:VCC) IC120.14(P:VCC) IC121.16(VCC) IC122.20(VCC) IC123.20(VCC) IC124.14(P:VCC) IC125.20(VCC) IC126.20(VCC) IC127.14(P:VCC) IC128.16(VCC) IC130.14(P:VCC) IC131.14(P:VCC) IC132.14(P:VCC) IC133.14(P:VCC) IC134.20(VCC) IC135.20(VCC) IC136.20(VCC) IC137.20(VCC) IC138.14(P:VCC) IC139.16(VCC) IC140.20(VCC) IC141.14(P:VCC) IC143.14(P:VCC) IC144.16(VCC) IC145.20(VCC) IC146.20(VCC) IC147.14(P:VCC) IC148.14(P:VCC) IC149.14(P:VCC) IC150.14(P:VCC) IC151.14(P:VCC) IC152.14(P:VCC) IC153.20(VCC) IC154.20(VCC) IC155.16(VCC) IC156.16(VCC) IC157.14(P:VCC) IC158.14(P:VCC) IC161.14(P:VCC) IC162.20(VCC) IC163.14(P:VCC) IC164.14(P:VCC) IC165.20(VCC) IC166.20(VCC) IC167.16(VCC) IC168.14(P:VCC) IC169.16(VCC) IC170.14(P:VCC) IC171.16(VCC) IC172.16(VCC) IC173.16(VCC) IC174.14(P:VCC) IC175.14(P:VCC) IC176.20(P:VCC) IC177.14(P:VCC) IC178.20(P:VCC) IC179.20(P:VCC) IC180.20(VCC) IC181.20(P:VCC) IC182.20(P:VCC) IC183.20(P:VCC) IC184.20(VCC) IC185.20(VCC) IC187.14(P:VCC) IC188.14(P:VCC) IC189.20(VCC) IC190.14(P:VCC) IC191.14(P:VCC) IC192.14(P:VCC) IC193.14(P:VCC) IC194.14(P:VCC) IC197.14(P:VCC) IC198.14(P:VCC) IC199.14(P:VCC) IC200.14(P:VCC) IC201.14(P:VCC) IC202.14(P:VCC) IC203.14(P:VCC) IC206.14(P:VCC) IC207.14(P:VCC) IC208.16(VCC) IC209.14(P:VCC) IC211.20(P:VCC) IC212.20(P:VCC) IC213.20(P:VCC) IC214.20(P:VCC) IC216.20(VCC) IC218.14(P:VCC) IC219.14(P:VCC) IC220.14(P:VCC) IC221.14(P:VCC) IC222.16(VCC) IC223.14(P:VCC) IC224.14(P:VCC) IC225.14(P:VCC) IC226.16(VCC) IC227.20(VCC) IC228.14(P:VCC) IC229.20(P:VCC) IC230.20(P:VCC) IC231.20(P:VCC) IC232.20(P:VCC) IC233.20(VCC) IC234.20(VCC) IC235.20(P:VCC) IC236.20(P:VCC) IC237.20(P:VCC) IC238.20(P:VCC) IC239.20(VCC) IC240.20(VCC) IC241.16(VCC) IC242.14(P:VCC) IC243.16(VCC) IC244.20(P:VCC) IC245.20(VCC) IC247.20(P:VCC) IC248.16(VCC) IC249.16(VCC) IC250.14(P:VCC) IC251.14(P:VCC) IC252.14(P:VCC) IC253.14(P:VCC) IC254.14(P:VCC) IC255.16(VCC) IC256.16(VCC) IC257.16(VCC) IC258.16(VCC)

## Library data of the parts
IC1 IC4-IC7 IC16 IC17 IC21 IC48 IC82 IC86 IC88 IC93 IC98-IC101 IC123 IC153 IC180 IC184 IC185 IC189 IC216 IC233 IC234 IC239 IC240 = 74xx-us:74*377: Octal D type FLIP FLOP, enable
IC2 IC3 IC9 IC19 IC28 IC29 IC102-IC104 IC113-IC118 IC122 IC125 IC140 IC145 IC146 IC154 IC165 IC166 IC245 = 74xx-us:74*541: Octal BUFFER and LINE DRIVER, 3-state; OC_FARNELL: unknown
IC10-IC13 IC24-IC27 IC30 IC31 IC69 IC105-IC112 IC176 IC178 IC179 IC181-IC183 IC244 IC247 = 74xx-us:74*244: Octal BUFFER and LINE DRIVER, 3-state; MF: TEXAS INSTRUMENTS; MPN: SN74LS244N; OC_FARNELL: 1739688
IC14 IC15 = 74xx-us:74*181: ARITHMETIC LOGIC UNIT function generator; OC_FARNELL: unknown
IC18 IC46 IC67 IC81 IC147 IC170 IC250 = 74xx-us:74*32: Quad 2-input OR gate; MF: TEXAS INSTRUMENTS; MPN: SN7432N; OC_FARNELL: 1607803
IC20 IC32 IC33 IC60-IC62 IC75-IC79 IC134-IC137 = 74xx-us:74*273: Octal D type FLIP FLOP, clear; OC_FARNELL: unknown
IC22 IC23 IC94-IC97 IC121 IC167 IC257 IC258 = 74xx-us:74*157: Quadruple 2-line to 1-line data SELECTOR/MULTIPLEXER; OC_FARNELL: unknown
IC34-IC38 IC40 IC41 IC56 IC155 IC156 IC208 IC241 IC243 IC255 IC256 = 74xx-us:74*153: Dual 4-line to 1-line data SELECTOR/MULTIPLEXER; OC_FARNELL: unknown
IC39 IC42 IC45 IC47 IC120 IC124 IC127 IC133 IC143 IC161 IC202 IC207 IC218-IC220 IC223-IC225 IC252 IC253 = 74xx-us:74*08: Quad 2-input AND gate; OC_FARNELL: unknown
IC43 IC54 IC57 IC59 IC83 IC84 IC119 IC198 = 74xx-us:74*04: Hex INVERTER; OC_FARNELL: unknown
IC44 = 74xx-us:74*74: Dual D type positive edge triggered FLIP FLOP, preset and clear; OC_FARNELL: unknown
IC49 IC55 IC63 IC68 IC169 IC171-IC173 = 74xx-us:74*257: Quadruple 2-to 1 line data SELECTOR/MULTIPLEXER; OC_FARNELL: unknown
IC50-IC53 = 74xx-us:74*283: 4-bit binary FULL ADDER, fast carry; OC_FARNELL: unknown
IC58 IC72 IC74 IC80 IC130 IC175 IC177 IC192-IC194 IC200 IC209 = 74xx-us:74*86: Quad 2-input EXCLUSIV-OR (XOR) gate; OC_FARNELL: unknown
IC64 IC85 IC132 IC138 IC150 IC151 IC157 IC158 IC191 = 74xx-us:74*10: Triple 3-input NAND gate
IC65 IC66 IC131 = 74xx-us:74*02: Quad 2-input NOR gate
IC70 = 74xx-us:74*151: Data SELECTOR/MULTIPLEXER
IC87 = 74xx-us:74*279: Quadruple S-R LATCH; OC_FARNELL: unknown
IC89-IC92 IC211-IC214 IC229-IC232 IC235-IC238 = 74xx-us:74*244: Octal BUFFER and LINE DRIVER, 3-state; OC_FARNELL: unknown
IC126 = 74xx-us:74*377: Octal D type FLIP FLOP, enable; OC_FARNELL: unknown
IC128 IC144 IC248 IC249 = 74xx-us:74*173: 4-bit D type REGISTER, 3-state
IC139 = 74xx-us:74*173: 4-bit D type REGISTER, 3-state; OC_FARNELL: unknown
IC141 = 74xx-us:74*11: Triple 3-input AND gate
IC148 IC149 IC254 = 74xx-us:74*04: Hex INVERTER
IC152 IC190 IC201 IC203 IC206 IC228 IC242 = 74xx-us:74*00: Quad 2-input NAND gate
IC162 IC227 = 74xx-us:74*273: Octal D type FLIP FLOP, clear
IC163 IC164 IC168 IC174 IC187 IC188 IC221 IC251 = 74xx-us:74*74: Dual D type positive edge triggered FLIP FLOP, preset and clear
IC197 IC199 = 74xx-us:74*260: Dual 5-input positive NOR gate; OC_FARNELL: unknown
IC222 = 74xx-us:74*138: 3-line to 8-line DECODER/DEMULTIPLEXER
IC226 = 74xx-us:74*148: 10-line to 4-line and 8-line to 3-line PRIORITY ENCODER
R1-R3 R9 = rcl:R-US_: RESISTOR, American symbol; OC_FARNELL: unknown
RN1-RN5 = resistor-dil:8R-N: DIL RESISTOR; OC_FARNELL: unknown; OC_NEWARK: unknown
S1 S2 S4 = switch:TL36PO: TINY SWITCH ON - ON Source: http://www2.produktinfo.conrad.com/datenblaetter/700000-724999/705152-da-01-de-Subminiaturschalter_TL_36YO.pdf; OC_FARNELL: unknown
SW3 = special:SW-C10: SWITCH 10-step rotary switch; OC_FARNELL: unknown
U$1-U$12 = atmel_28c:AT28C256-28DIP: IC EEPROM 256KBIT 150NS 28DIP; OC_FARNELL: unknown