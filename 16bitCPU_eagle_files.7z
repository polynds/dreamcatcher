# EAGLE schematic main_pcmar_adder (EAGLE 7.6.0), part 2 of 2
## Nets (continued)
Unconnected: IC1.11(CLK) IC1.18(8D) IC2.1(A:G) IC2.2(A:A1) IC2.4(A:A2) IC2.6(A:A3) IC2.8(A:A4) IC2.12(A:Y4) IC2.14(A:Y3) IC2.16(A:Y2) IC2.18(A:Y1) IC3.1(A:G) IC3.2(A:A1) IC3.4(A:A2) IC3.6(A:A3) IC3.8(A:A4) IC3.12(A:Y4) IC3.14(A:Y3) IC3.16(A:Y2) IC3.18(A:Y1) IC4.11(CLK) IC5.11(CLK) IC6.11(CLK) IC8.9(3Y) IC8.12(4Y) IC10.3(B:Y4) IC10.5(B:Y3) IC10.7(B:Y2) IC10.9(B:Y1) IC10.11(B:A1) IC10.13(B:A2) IC10.15(B:A3) IC10.17(B:A4) IC10.19(B:G) IC11.3(B:Y4) IC11.5(B:Y3) IC11.7(B:Y2) IC11.9(B:Y1) IC11.11(B:A1) IC11.13(B:A2) IC11.15(B:A3) IC11.17(B:A4) IC11.19(B:G) IC12.3(B:Y4) IC12.5(B:Y3) IC12.7(B:Y2) IC12.9(B:Y1) IC12.11(B:A1) IC12.13(B:A2) IC12.15(B:A3) IC12.17(B:A4) IC12.19(B:G) IC13.3(B:Y4) IC13.5(B:Y3) IC13.7(B:Y2) IC13.9(B:Y1) IC13.11(B:A1) IC13.13(B:A2) IC13.15(B:A3) IC13.17(B:A4) IC13.19(B:G) IC14.14(A=B) IC14.15(P) IC14.17(G) IC15.14(A=B) IC15.15(P) IC15.17(G) IC16.11(CLK) IC17.11(CLK) IC18.1(A:I0) IC18.2(A:I1) IC18.3(A:O) IC18.8(C:O) IC18.9(C:I0) IC18.10(C:I1) IC18.11(D:O) IC18.12(D:I0) IC18.13(D:I1) IC19.2(A:A1) IC19.4(A:A2) IC19.6(A:A3) IC19.8(A:A4) IC19.11(B:A1) IC19.13(B:A2) IC19.15(B:A3) IC19.17(B:A4) IC20.5(Q2) IC20.6(Q3) IC20.9(Q4) IC20.11(CLK) IC20.12(Q5) IC20.15(Q6) IC20.16(Q7) IC21.11(CLK) IC24.1(A:G) IC24.2(A:A1) IC24.4(A:A2) IC24.6(A:A3) IC24.8(A:A4) IC24.12(A:Y4) IC24.14(A:Y3) IC24.16(A:Y2) IC24.18(A:Y1) IC25.1(A:G) IC25.2(A:A1) IC25.4(A:A2) IC25.6(A:A3) IC25.8(A:A4) IC25.12(A:Y4) IC25.14(A:Y3) IC25.16(A:Y2) IC25.18(A:Y1) IC26.1(A:G) IC26.2(A:A1) IC26.4(A:A2) IC26.6(A:A3) IC26.8(A:A4) IC26.12(A:Y4) IC26.14(A:Y3) IC26.16(A:Y2) IC26.18(A:Y1) IC27.1(A:G) IC27.2(A:A1) IC27.4(A:A2) IC27.6(A:A3) IC27.8(A:A4) IC27.12(A:Y4) IC27.14(A:Y3) IC27.16(A:Y2) IC27.18(A:Y1) IC28.1(A:G) IC28.2(A:A1) IC28.4(A:A2) IC28.6(A:A3) IC28.8(A:A4) IC28.12(A:Y4) IC28.14(A:Y3) IC28.16(A:Y2) IC28.18(A:Y1) IC29.1(A:G) IC29.2(A:A1) IC29.4(A:A2) IC29.6(A:A3) IC29.8(A:A4) IC29.12(A:Y4) IC29.14(A:Y3) IC29.16(A:Y2) IC29.18(A:Y1) IC30.3(B:Y4) IC30.5(B:Y3) IC30.7(B:Y2) IC30.9(B:Y1) IC30.11(B:A1) IC30.13(B:A2) IC30.15(B:A3) IC30.17(B:A4) IC30.19(B:G) IC31.3(B:Y4) IC31.5(B:Y3) IC31.7(B:Y2) IC31.9(B:Y1) IC31.11(B:A1) IC31.13(B:A2) IC31.15(B:A3) IC31.17(B:A4) IC31.19(B:G) IC32.17(D7) IC32.18(D8) IC33.16(Q7) IC33.19(Q8) IC34.1(1G) IC34.15(2G) IC35.1(1G) IC35.15(2G) IC36.1(1G) IC36.15(2G) IC37.1(1G) IC37.15(2G) IC38.1(1G) IC38.15(2G) IC39.4(B:I0) IC39.5(B:I1) IC39.6(B:O) IC39.8(C:O) IC39.9(C:I0) IC39.10(C:I1) IC39.11(D:O) IC39.12(D:I0) IC39.13(D:I1) IC40.1(1G) IC40.15(2G) IC41.1(1G) IC41.15(2G) IC42.1(A:I0) IC42.2(A:I1) IC42.3(A:O) IC42.8(C:O) IC42.9(C:I0) IC42.10(C:I1) IC42.11(D:O) IC42.12(D:I0) IC42.13(D:I1) IC43.1(A:I) IC43.2(A:O) IC43.5(C:I) IC43.6(C:O) IC43.8(D:O) IC43.9(D:I) IC43.10(E:O) IC43.11(E:I) IC43.12(F:O) IC43.13(F:I) IC44.1(A:CLR) IC44.4(A:PRE) IC44.6(A:!Q) IC44.8(B:!Q) IC44.9(B:Q) IC44.10(B:PRE) IC44.11(B:CLK) IC44.12(B:D) IC44.13(B:CLR) IC45.1(A:I) IC45.2(A:O) IC45.5(C:I) IC45.6(C:O) IC45.8(D:O) IC45.9(D:I) IC45.10(E:O) IC45.11(E:I) IC45.12(F:O) IC45.13(F:I) IC46.1(G) IC46.11(CLK) IC48.11(CLK) IC53.9(C4) IC54.1(A:CLR) IC54.4(A:PRE) IC54.6(A:!Q) IC54.8(B:!Q) IC54.9(B:Q) IC54.10(B:PRE) IC54.11(B:CLK) IC54.12(B:D) IC54.13(B:CLR) IC56.9(2Y) IC56.10(2C0) IC56.11(2C1) IC56.12(2C2) IC56.13(2C3) IC57.5(C:I) IC57.6(C:O) IC57.8(D:O) IC57.9(D:I) IC57.10(E:O) IC57.11(E:I) IC57.12(F:O) IC57.13(F:I) IC58.4(B:I0) IC58.5(B:I1) IC58.6(B:O) IC58.8(C:O) IC58.9(C:I0) IC58.10(C:I1) IC58.11(D:O) IC58.12(D:I0) IC58.13(D:I1) IC59.15(G) IC60.1(CLR) IC60.2(Q1) IC60.5(Q2) IC60.6(Q3) IC60.9(Q4) IC60.12(Q5) IC60.15(Q6) IC60.16(Q7) IC60.19(Q8) IC61.1(CLR) IC61.2(Q1) IC61.5(Q2) IC61.6(Q3) IC61.9(Q4) IC61.12(Q5) IC61.15(Q6) IC61.16(Q7) IC61.19(Q8) IC62.1(CLR) IC62.2(Q1) IC62.5(Q2) IC62.6(Q3) IC62.9(Q4) IC62.12(Q5) IC62.15(Q6) IC62.16(Q7) IC62.19(Q8) IC64.8(B:O) IC64.9(B:I0) IC64.10(B:I1) IC64.12(B:I2) IC64.13(B:I3) IC65.3(B:I) IC65.4(B:O) IC65.5(C:I) IC65.6(C:O) IC65.8(D:O) IC65.9(D:I) IC65.10(E:O) IC65.11(E:I) IC65.12(F:O) IC65.13(F:I) IC66.4(B:I0) IC66.5(B:I1) IC66.6(B:O) IC66.8(C:O) IC66.9(C:I0) IC66.10(C:I1) IC66.11(D:O) IC66.12(D:I0) IC66.13(D:I1) IC67.1(A:I0) IC67.2(A:I1) IC67.3(A:O) IC67.8(C:O) IC67.9(C:I0) IC67.10(C:I1) IC67.11(D:O) IC67.12(D:I0) IC67.13(D:I1) IC68.7(C0) IC70.1(A:G) IC70.2(A:A1) IC70.4(A:A2) IC70.6(A:A3) IC70.8(A:A4) IC70.12(A:Y4) IC70.14(A:Y3) IC70.16(A:Y2) IC70.18(A:Y1) IC71.1(A:G) IC71.2(A:A1) IC71.4(A:A2) IC71.6(A:A3) IC71.8(A:A4) IC71.12(A:Y4) IC71.14(A:Y3) IC71.16(A:Y2) IC71.18(A:Y1) IC72.1(A:I0) IC72.2(A:I1) IC72.3(A:O) IC72.8(C:O) IC72.9(C:I0) IC72.10(C:I1) IC72.11(D:O) IC72.12(D:I0) IC72.13(D:I1) IC73.5(2A) IC73.6(2B) IC73.7(2Y) IC73.9(3Y) IC73.10(3B) IC73.11(3A) IC73.12(4Y) IC73.13(4B) IC73.14(4A) IC73.15(G) IC74.1(A:I0) IC74.2(A:I1) IC74.3(A:O) IC74.8(C:O) IC74.9(C:I0) IC74.10(C:I1) IC74.11(D:O) IC74.12(D:I0) IC74.13(D:I1) IC75.2(Q1) IC75.5(Q2) IC75.6(Q3) IC75.9(Q4) IC75.12(Q5) IC75.15(Q6) IC80.1(A:I0) IC80.2(A:I1) IC80.3(A:O) IC80.8(C:O) IC80.9(C:I0) IC80.10(C:I1) IC80.11(D:O) IC80.12(D:I0) IC80.13(D:I1) IC81.1(A:I0) IC81.2(A:I1) IC81.3(A:O) IC81.8(C:O) IC81.9(C:I0) IC81.10(C:I1) IC81.11(D:O) IC81.12(D:I0) IC81.13(D:I1) IC86.11(CLK) IC87.2(A:S1) IC87.5(C:R) IC87.6(C:S) IC87.7(C:Q) IC87.9(B:Q) IC87.10(B:R) IC87.11(B:S1) IC87.12(B:S2) IC87.13(D:Q) IC87.14(D:R) IC87.15(D:S) IC88.11(CLK) IC89.3(B:Y4) IC89.5(B:Y3) IC89.7(B:Y2) IC89.9(B:Y1) IC89.11(B:A1) IC89.13(B:A2) IC89.15(B:A3) IC89.17(B:A4) IC89.19(B:G) IC90.3(B:Y4) IC90.5(B:Y3) IC90.7(B:Y2) IC90.9(B:Y1) IC90.11(B:A1) IC90.13(B:A2) IC90.15(B:A3) IC90.17(B:A4) IC90.19(B:G) IC91.3(B:Y4) IC91.5(B:Y3) IC91.7(B:Y2) IC91.9(B:Y1) IC91.11(B:A1) IC91.13(B:A2) IC91.15(B:A3) IC91.17(B:A4) IC91.19(B:G) IC92.3(B:Y4) IC92.5(B:Y3) IC92.7(B:Y2) IC92.9(B:Y1) IC92.11(B:A1) IC92.13(B:A2) IC92.15(B:A3) IC92.17(B:A4) IC92.19(B:G) IC98.11(CLK) IC99.11(CLK) IC100.11(CLK) IC101.11(CLK) IC102.1(A:G) IC102.2(A:A1) IC102.4(A:A2) IC102.6(A:A3) IC102.8(A:A4) IC102.12(A:Y4) IC102.14(A:Y3) IC102.16(A:Y2) IC102.18(A:Y1) IC105.1(A:G) IC105.2(A:A1) IC105.4(A:A2) IC105.6(A:A3) IC105.8(A:A4) IC105.12(A:Y4) IC105.14(A:Y3) IC105.16(A:Y2) IC105.18(A:Y1) IC106.1(A:G) IC106.2(A:A1) IC106.4(A:A2) IC106.6(A:A3) IC106.8(A:A4) IC106.12(A:Y4) IC106.14(A:Y3) IC106.16(A:Y2) IC106.18(A:Y1) IC107.1(A:G) IC107.2(A:A1) IC107.4(A:A2) IC107.6(A:A3) IC107.8(A:A4) IC107.12(A:Y4) IC107.14(A:Y3) IC107.16(A:Y2) IC107.18(A:Y1) IC108.1(A:G) IC108.2(A:A1) IC108.4(A:A2) IC108.6(A:A3) IC108.8(A:A4) IC108.12(A:Y4) IC108.14(A:Y3) IC108.16(A:Y2) IC108.18(A:Y1) IC109.1(A:G) IC109.2(A:A1) IC109.4(A:A2) IC109.6(A:A3) IC109.8(A:A4) IC109.12(A:Y4) IC109.14(A:Y3) IC109.16(A:Y2) IC109.18(A:Y1) IC110.1(A:G) IC110.2(A:A1) IC110.4(A:A2) IC110.6(A:A3) IC110.8(A:A4) IC110.12(A:Y4) IC110.14(A:Y3) IC110.16(A:Y2) IC110.18(A:Y1) IC111.1(A:G) IC111.2(A:A1) IC111.4(A:A2) IC111.6(A:A3) IC111.8(A:A4) IC111.12(A:Y4) IC111.14(A:Y3) IC111.16(A:Y2) IC111.18(A:Y1) IC112.1(A:G) IC112.2(A:A1) IC112.4(A:A2) IC112.6(A:A3) IC112.8(A:A4) IC112.12(A:Y4) IC112.14(A:Y3) IC112.16(A:Y2) IC112.18(A:Y1) IC113.1(A:G) IC113.2(A:A1) IC113.4(A:A2) IC113.6(A:A3) IC113.8(A:A4) IC113.12(A:Y4) IC113.14(A:Y3) IC113.16(A:Y2) IC113.18(A:Y1) IC114.1(A:G) IC114.2(A:A1) IC114.4(A:A2) IC114.6(A:A3) IC114.8(A:A4) IC114.12(A:Y4) IC114.14(A:Y3) IC114.16(A:Y2) IC114.18(A:Y1) IC115.1(A:G) IC115.2(A:A1) IC115.4(A:A2) IC115.6(A:A3) IC115.8(A:A4) IC115.12(A:Y4) IC115.14(A:Y3) IC115.16(A:Y2) IC115.18(A:Y1) IC116.1(A:G) IC116.2(A:A1) IC116.4(A:A2) IC116.6(A:A3) IC116.8(A:A4) IC116.12(A:Y4) IC116.14(A:Y3) IC116.16(A:Y2) IC116.18(A:Y1) IC117.1(A:G) IC117.2(A:A1) IC117.4(A:A2) IC117.6(A:A3) IC117.8(A:A4) IC117.12(A:Y4) IC117.14(A:Y3) IC117.16(A:Y2) IC117.18(A:Y1) IC118.1(G1) IC118.11(Y8) IC118.12(Y7) IC118.19(G2) IC123.11(CLK) IC123.18(8D) IC124.1(A:G) IC124.2(A:A1) IC124.4(A:A2) IC124.6(A:A3) IC124.8(A:A4) IC124.12(A:Y4) IC124.14(A:Y3) IC124.16(A:Y2) IC124.18(A:Y1) IC125.1(A:G) IC125.2(A:A1) IC125.4(A:A2) IC125.6(A:A3) IC125.8(A:A4) IC125.12(A:Y4) IC125.14(A:Y3) IC125.16(A:Y2) IC125.18(A:Y1) IC126.11(CLK) IC126.12(5Q) IC126.13(5D) IC126.14(6D) IC126.15(6Q) IC126.16(7Q) IC126.17(7D) IC126.18(8D) IC126.19(8Q) IC128.9(C4) IC130.1(A:I0) IC130.2(A:I1) IC130.3(A:O) IC130.8(C:O) IC130.9(C:I0) IC130.10(C:I1) IC130.11(D:O) IC130.12(D:I0) IC130.13(D:I1) IC131.8(B:O) IC131.9(B:I0) IC131.10(B:I1) IC131.12(B:I2) IC131.13(B:I3) IC132.3(B:I) IC132.4(B:O) IC132.5(C:I) IC132.6(C:O) IC132.8(D:O) IC132.9(D:I) IC132.10(E:O) IC132.11(E:I) IC132.12(F:O) IC132.13(F:I) IC133.3(A:O) IC133.4(B:I0) IC133.5(B:I1) IC133.6(B:O) IC133.8(C:O) IC133.9(C:I0) IC133.10(C:I1) IC133.11(D:O) IC133.12(D:I0) IC133.13(D:I1) IC138.4(B:I0) IC138.5(B:I1) IC138.6(B:O) IC138.8(C:O) IC138.9(C:I0) IC138.10(C:I1) IC138.11(D:O) IC138.12(D:I0) IC138.13(D:I1) IC139.4(Q2) IC139.5(Q3) IC139.6(Q4) IC139.11(D4) IC139.12(D3) IC139.13(D2) IC140.1(G1) IC140.19(G2) IC141.3(B:I) IC141.4(B:O) IC141.5(C:I) IC141.6(C:O) IC141.8(D:O) IC141.9(D:I) IC141.10(E:O) IC141.11(E:I) IC141.12(F:O) IC141.13(F:I) IC142.1(1G) IC142.15(2G) IC143.4(B:I0) IC143.5(B:I1) IC143.6(B:O) IC143.8(C:O) IC143.9(C:I0) IC143.10(C:I1) IC143.11(D:O) IC143.12(D:I0) IC143.13(D:I1) IC145.1(A:G) IC145.2(A:A1) IC145.4(A:A2) IC145.6(A:A3) IC145.8(A:A4) IC145.12(A:Y4) IC145.14(A:Y3) IC145.16(A:Y2) IC145.18(A:Y1) IC146.1(A:G) IC146.2(A:A1) IC146.4(A:A2) IC146.6(A:A3) IC146.8(A:A4) IC146.12(A:Y4) IC146.14(A:Y3) IC146.16(A:Y2) IC146.18(A:Y1) IC147.4(B:I0) IC147.5(B:I1) IC147.6(B:O) IC147.8(C:O) IC147.9(C:I0) IC147.10(C:I1) IC147.11(D:O) IC147.12(D:I0) IC147.13(D:I1) IC148.9(C4) IC150.3(B:I) IC150.4(B:O) IC150.5(C:I) IC150.6(C:O) IC150.8(D:O) IC150.9(D:I) IC150.10(E:O) IC150.11(E:I) IC150.12(F:O) IC150.13(F:I) IC151.3(B:I) IC151.4(B:O) IC151.5(C:I) IC151.6(C:O) IC151.8(D:O) IC151.9(D:I) IC151.10(E:O) IC151.11(E:I) IC151.12(F:O) IC151.13(F:I) IC152.15(G) IC153.11(CLK) IC154.1(A:G) IC154.2(A:A1) IC154.4(A:A2) IC154.6(A:A3) IC154.8(A:A4) IC154.12(A:Y4) IC154.14(A:Y3) IC154.16(A:Y2) IC154.18(A:Y1) IC155.1(A:G) IC155.2(A:A1) IC155.4(A:A2) IC155.6(A:A3) IC155.8(A:A4) IC155.12(A:Y4) IC155.14(A:Y3) IC155.16(A:Y2) IC155.18(A:Y1) IC156.15(G) IC157.3(B:I) IC157.4(B:O) IC157.5(C:I) IC157.6(C:O) IC157.8(D:O) IC157.9(D:I) IC157.10(E:O) IC157.11(E:I) IC157.12(F:O) IC157.13(F:I) IC158.3(B:I) IC158.4(B:O) IC158.5(C:I) IC158.6(C:O) IC158.8(D:O) IC158.9(D:I) IC158.10(E:O) IC158.11(E:I) IC158.12(F:O) IC158.13(F:I) IC159.15(G) IC160.15(G) IC161.10(3B) IC161.13(4B) IC161.15(G) IC162.3(1B) IC162.6(2B) IC162.10(3B) IC162.13(4B) IC162.15(G) IC163.6(2B) IC163.10(3B) IC163.13(4B) IC163.15(G) IC164.3(1B) IC164.6(2B) IC164.10(3B) IC164.13(4B) IC164.15(G) IC165.1(G1) IC165.2(A1) IC165.3(A2) IC165.4(A3) IC165.5(A4) IC165.6(A5) IC165.7(A6) IC165.8(A7) IC165.9(A8) IC165.11(Y8) IC165.12(Y7) IC165.14(Y5) IC165.15(Y4) IC165.16(Y3) IC165.17(Y2) IC165.18(Y1) IC165.19(G2) IC166.1(G1) IC166.4(A3) IC166.5(A4) IC166.6(A5) IC166.7(A6) IC166.8(A7) IC166.9(A8) IC166.11(Y8) IC166.12(Y7) IC166.13(Y6) IC166.14(Y5) IC166.15(Y4) IC166.16(Y3) IC166.19(G2) IC167.5(2A) IC167.6(2B) IC167.7(2Y) IC167.9(3Y) IC167.10(3B) IC167.11(3A) IC167.12(4Y) IC167.13(4B) IC167.14(4A) IC168.4(B:I0) IC168.5(B:I1) IC168.6(B:O) IC168.8(C:O) IC168.9(C:I0) IC168.10(C:I1) IC168.11(D:O) IC168.12(D:I0) IC168.13(D:I1) IC169.15(G) IC170.1(A:I0) IC170.2(A:I1) IC170.3(A:O) IC170.8(C:O) IC170.9(C:I0) IC170.10(C:I1) IC170.11(D:O) IC170.12(D:I0) IC170.13(D:I1) IC171.15(G) IC172.9(3Y) IC172.12(4Y) IC172.15(G) IC173.15(G) IC174.1(A:I) IC174.2(A:O) IC174.5(C:I) IC174.6(C:O) IC174.8(D:O) IC174.9(D:I) IC174.10(E:O) IC174.11(E:I) IC174.12(F:O) IC174.13(F:I) IC175.6(A:!Q) IC175.8(B:!Q) IC175.9(B:Q) IC175.10(B:PRE) IC175.11(B:CLK) IC175.12(B:D) IC175.13(B:CLR) IC176.3(B:Y4) IC176.5(B:Y3) IC176.7(B:Y2) IC176.9(B:Y1) IC176.11(B:A1) IC176.13(B:A2) IC176.15(B:A3) IC176.17(B:A4) IC176.19(B:G) IC177.6(A:!Q) IC177.8(B:!Q) IC177.9(B:Q) IC177.10(B:PRE) IC177.11(B:CLK) IC177.12(B:D) IC177.13(B:CLR) IC178.3(B:Y4) IC178.5(B:Y3) IC178.7(B:Y2) IC178.9(B:Y1) IC178.11(B:A1) IC178.13(B:A2) IC178.15(B:A3) IC178.17(B:A4) IC178.19(B:G) IC179.3(B:Y4) IC179.5(B:Y3) IC179.7(B:Y2) IC179.9(B:Y1) IC179.11(B:A1) IC179.13(B:A2) IC179.15(B:A3) IC179.17(B:A4) IC179.19(B:G) IC180.11(CLK) IC181.3(B:Y4) IC181.5(B:Y3) IC181.7(B:Y2) IC181.9(B:Y1) IC181.11(B:A1) IC181.13(B:A2) IC181.15(B:A3) IC181.17(B:A4) IC181.19(B:G) IC182.3(B:Y4) IC182.5(B:Y3) IC182.7(B:Y2) IC182.9(B:Y1) IC182.11(B:A1) IC182.13(B:A2) IC182.15(B:A3) IC182.17(B:A4) IC182.19(B:G) IC183.3(B:Y4) IC183.5(B:Y3) IC183.7(B:Y2) IC183.9(B:Y1) IC183.11(B:A1) IC183.13(B:A2) IC183.15(B:A3) IC183.17(B:A4) IC183.19(B:G) IC184.11(CLK) IC185.11(CLK) IC186.1(A:G) IC186.2(A:A1) IC186.4(A:A2) IC186.6(A:A3) IC186.8(A:A4) IC186.12(A:Y4) IC186.14(A:Y3) IC186.16(A:Y2) IC186.18(A:Y1) IC187.5(2A) IC187.11(3A) IC187.14(4A) IC187.15(G) IC188.2(1A) IC188.5(2A) IC188.11(3A) IC188.14(4A) IC188.15(G) IC190.2(1A) IC190.5(2A) IC190.11(3A) IC190.14(4A) IC190.15(G) IC191.2(1A) IC191.5(2A) IC191.9(3Y) IC191.12(4Y) IC191.15(G) IC192.3(A:CLK) IC192.6(A:!Q) IC192.8(B:!Q) IC192.9(B:Q) IC192.10(B:PRE) IC192.11(B:CLK) IC192.12(B:D) IC192.13(B:CLR) IC193.1(A:I) IC193.2(A:O) IC193.5(C:I) IC193.6(C:O) IC193.8(D:O) IC193.9(D:I) IC193.10(E:O) IC193.11(E:I) IC193.12(F:O) IC193.13(F:I) IC194.1(A:G) IC194.2(A:A1) IC194.4(A:A2) IC194.6(A:A3) IC194.8(A:A4) IC194.12(A:Y4) IC194.14(A:Y3) IC194.16(A:Y2) IC194.18(A:Y1) IC195.1(A:G) IC195.2(A:A1) IC195.4(A:A2) IC195.6(A:A3) IC195.8(A:A4) IC195.12(A:Y4) IC195.14(A:Y3) IC195.16(A:Y2) IC195.18(A:Y1) IC196.1(A:G) IC196.2(A:A1) IC196.4(A:A2) IC196.6(A:A3) IC196.8(A:A4) IC196.12(A:Y4) IC196.14(A:Y3) IC196.16(A:Y2) IC196.18(A:Y1) IC197.4(B:I0) IC197.6(B:O) IC197.8(B:I1) IC197.9(B:I2) IC197.10(B:I3) IC197.11(B:I4) IC198.3(B:I) IC198.4(B:O) IC198.5(C:I) IC198.6(C:O) IC198.8(D:O) IC198.9(D:I) IC198.10(E:O) IC198.11(E:I) IC198.12(F:O) IC198.13(F:I) IC199.4(B:I0) IC199.6(B:O) IC199.8(B:I1) IC199.9(B:I2) IC199.10(B:I3) IC199.11(B:I4) IC200.4(B:I0) IC200.5(B:I1) IC200.6(B:O) IC200.8(C:O) IC200.9(C:I0) IC200.10(C:I1) IC200.11(D:O) IC200.12(D:I0) IC200.13(D:I1) IC209.4(B:I0) IC209.5(B:I1) IC209.6(B:O) IC209.8(C:O) IC209.9(C:I0) IC209.10(C:I1) IC209.11(D:O) IC209.12(D:I0) IC209.13(D:I1) IC210.1(A:G) IC210.2(A:A1) IC210.4(A:A2) IC210.6(A:A3) IC210.8(A:A4) IC210.12(A:Y4) IC210.14(A:Y3) IC210.16(A:Y2) IC210.18(A:Y1) IC211.3(B:Y4) IC211.5(B:Y3) IC211.7(B:Y2) IC211.9(B:Y1) IC211.11(B:A1) IC211.13(B:A2) IC211.15(B:A3) IC211.17(B:A4) IC211.19(B:G) IC212.3(B:Y4) IC212.5(B:Y3) IC212.7(B:Y2) IC212.9(B:Y1) IC212.11(B:A1) IC212.13(B:A2) IC212.15(B:A3) IC212.17(B:A4) IC212.19(B:G) IC213.3(B:Y4) IC213.5(B:Y3) IC213.7(B:Y2) IC213.9(B:Y1) IC213.11(B:A1) IC213.13(B:A2) IC213.15(B:A3) IC213.17(B:A4) IC213.19(B:G) IC214.3(B:Y4) IC214.5(B:Y3) IC214.7(B:Y2) IC214.9(B:Y1) IC214.11(B:A1) IC214.13(B:A2) IC214.15(B:A3) IC214.17(B:A4) IC214.19(B:G) IC215.1(A:G) IC215.2(A:A1) IC215.4(A:A2) IC215.6(A:A3) IC215.8(A:A4) IC215.12(A:Y4) IC215.14(A:Y3) IC215.16(A:Y2) IC215.18(A:Y1) IC216.11(CLK) IC229.3(B:Y4) IC229.5(B:Y3) IC229.7(B:Y2) IC229.9(B:Y1) IC229.11(B:A1) IC229.13(B:A2) IC229.15(B:A3) IC229.17(B:A4) IC229.19(B:G) IC230.3(B:Y4) IC230.5(B:Y3) IC230.7(B:Y2) IC230.9(B:Y1) IC230.11(B:A1) IC230.13(B:A2) IC230.15(B:A3) IC230.17(B:A4) IC230.19(B:G) IC231.3(B:Y4) IC231.5(B:Y3) IC231.7(B:Y2) IC231.9(B:Y1) IC231.11(B:A1) IC231.13(B:A2) IC231.15(B:A3) IC231.17(B:A4) IC231.19(B:G) IC232.3(B:Y4) IC232.5(B:Y3) IC232.7(B:Y2) IC232.9(B:Y1) IC232.11(B:A1) IC232.13(B:A2) IC232.15(B:A3) IC232.17(B:A4) IC232.19(B:G) IC233.11(CLK) IC234.11(CLK) IC235.3(B:Y4) IC235.5(B:Y3) IC235.7(B:Y2) IC235.9(B:Y1) IC235.11(B:A1) IC235.13(B:A2) IC235.15(B:A3) IC235.17(B:A4) IC235.19(B:G) IC236.3(B:Y4) IC236.5(B:Y3) IC236.7(B:Y2) IC236.9(B:Y1) IC236.11(B:A1) IC236.13(B:A2) IC236.15(B:A3) IC236.17(B:A4) IC236.19(B:G) IC237.3(B:Y4) IC237.5(B:Y3) IC237.7(B:Y2) IC237.9(B:Y1) IC237.11(B:A1) IC237.13(B:A2) IC237.15(B:A3) IC237.17(B:A4) IC237.19(B:G) IC238.3(B:Y4) IC238.5(B:Y3) IC238.7(B:Y2) IC238.9(B:Y1) IC238.11(B:A1) IC238.13(B:A2) IC238.15(B:A3) IC238.17(B:A4) IC238.19(B:G) IC239.11(CLK) IC240.11(CLK) IC245.3(B:Y4) IC245.5(B:Y3) IC245.7(B:Y2) IC245.9(B:Y1) IC245.11(B:A1) IC245.13(B:A2) IC245.15(B:A3) IC245.17(B:A4) IC245.19(B:G) IC246.3(B:Y4) IC246.5(B:Y3) IC246.7(B:Y2) IC246.9(B:Y1) IC246.11(B:A1) IC246.13(B:A2) IC246.15(B:A3) IC246.17(B:A4) IC246.19(B:G) IC247.3(B:Y4) IC247.5(B:Y3) IC247.7(B:Y2) IC247.9(B:Y1) IC247.11(B:A1) IC247.13(B:A2) IC247.15(B:A3) IC247.17(B:A4) IC247.19(B:G) IC248.3(B:Y4) IC248.5(B:Y3) IC248.7(B:Y2) IC248.9(B:Y1) IC248.11(B:A1) IC248.13(B:A2) IC248.15(B:A3) IC248.17(B:A4) IC248.19(B:G) S2.1(O) SW3.8 U$1.28(VCC) U$2.28(VCC) U$3.28(VCC) U$4.28(VCC) U$5.28(VCC) U$6.28(VCC) U$7.28(VCC) U$8.28(VCC) U$9.28(VCC) U$10.1(A14) U$10.2(A12) U$10.3(A7) U$10.4(A6) U$10.5(A5) U$10.6(A4) U$10.7(A3) U$10.8(A2) U$10.9(A1) U$10.10(A0) U$10.14(GND) U$10.20(/CE) U$10.21(A10) U$10.22(/OE) U$10.23(A11) U$10.24(A9) U$10.25(A8) U$10.26(A13) U$10.27(/WE) U$10.28(VCC) U$11.1(A14) U$11.2(A12) U$11.3(A7) U$11.4(A6) U$11.5(A5) U$11.6(A4) U$11.7(A3) U$11.8(A2) U$11.9(A1) U$11.10(A0) U$11.14(GND) U$11.20(/CE) U$11.21(A10) U$11.22(/OE) U$11.23(A11) U$11.24(A9) U$11.25(A8) U$11.26(A13) U$11.27(/WE) U$11.28(VCC) U$12.1(A14) U$12.2(A12) U$12.3(A7) U$12.4(A6) U$12.5(A5) U$12.6(A4) U$12.7(A3) U$12.8(A2) U$12.9(A1) U$12.10(A0) U$12.14(GND) U$12.20(/CE) U$12.21(A10) U$12.22(/OE) U$12.23(A11) U$12.24(A9) U$12.25(A8) U$12.26(A13) U$12.27(/WE) U$12.28(VCC)

## Buses
XBUS[0..7]
ZBUS[0..7]
YBUS[0..7]
AD[0..15]
MDR_IN_BUS[0..7]
U_AD[0..13]
DATA[0..7]
U_AD_BUFF[0..13]
Z_BUS[0..7]
U_ADDR_BUFF1_[0..13]

## Notes on the sheet
- INTERRUPT REQUEST
- IMMX
- TDR0_L
- DMA REQUEST
  doubly synchronized
- TDR0_H
- TDR1_L
- SINGLE STEP CLOCK
- SINGLE STEP CLOCK
- TDR1_H
- fast clock
- slow clock
- OFFSET(6)
- U-ADDRESS MUX
- AL
- Z BUS
- PC_L
- U-CODE ROMS
- U-ADDRESS
- IR | U-CODE FF'S
- AH
- ADDRESS & DATA BUSES NEED PULL DOWN RESISTORS 
  BECAUSE THE CPU BUS OUTPUTS HAVE 
  244'S WHICH ARE CLOSED MOST OF THE TIME.
- LOW | ADDRESS BUS | PC_H
- MARL
- LOW
- ADDER
- BL
- HIGH
- SP_L
- BH
- ADDER
- MARH
- MAR is tri-stated when in programming or DMA mode. | SP_H
- programming mode signal goes here to tell MAR to go tristate
- CL
- U-CODE FF'S
- BP_L
- CH
- HIGH
- BP_H
- DL
- U-ADDRESS MUX
- Z BUS
- MUX1
- DH
- U-ADDR MUX LOGIC
- U_FLAGS
- CARRY IN MUX
- CONDITION SOURCE
  PROGRAMMER'S FLAGS 
  OR
  U_CODE FLAGS
- DATA BUS
- BUS GOING INTO MDR INPUTS
- BUS GOING INTO MDR INPUTS
- X BUS
- MDR_L
- IMMY | MDR MUX
- MDR_H
- ALU
- alu_mode removed. OF is undefined if alu in logic mode anyway. | alu_op == add
- DATA BUS
- ALU_OP == SUB
- TDR0_L
- IMMY
- TDR0_H
- FROM MICROCODE
- TDR1_L
- TDR1_H
- THESE TDR'S ARE THE SAME ONES AS ARE CONNECTED TO THE X BUS

## Power pins joined to a net without a drawn wire
GND: IC1.10(GND) IC2.10(P:GND) IC3.10(P:GND) IC4.10(GND) IC5.10(GND) IC6.10(GND) IC7.10(GND) IC8.8(GND) IC9.10(P:GND) IC10.10(P:GND) IC11.10(P:GND) IC12.10(P:GND) IC13.10(P:GND) IC14.12(GND) IC15.12(GND) IC16.10(GND) IC17.10(GND) IC18.7(P:GND) IC19.10(P:GND) IC20.10(GND) IC21.10(GND) IC22.8(GND) IC23.8(GND) IC24.10(P:GND) IC25.10(P:GND) IC26.10(P:GND) IC27.10(P:GND) IC28.10(P:GND) IC29.10(P:GND) IC30.10(P:GND) IC31.10(P:GND) IC32.10(GND) IC33.10(GND) IC34.8(GND) IC35.8(GND) IC36.8(GND) IC37.8(GND) IC38.8(GND) IC39.7(P:GND) IC40.8(GND) IC41.8(GND) IC42.7(P:GND) IC43.7(P:GND) IC44.7(P:GND) IC45.7(P:GND) IC46.10(GND) IC47.8(GND) IC48.10(GND) IC49.8(GND) IC50.8(GND) IC51.8(GND) IC52.8(GND) IC53.8(GND) IC54.7(P:GND) IC55.8(GND) IC56.8(GND) IC57.7(P:GND) IC58.7(P:GND) IC59.8(GND) IC60.10(GND) IC61.10(GND) IC62.10(GND) IC64.7(P:GND) IC65.7(P:GND) IC66.7(P:GND) IC67.7(P:GND) IC68.8(GND) IC69.8(GND) IC70.10(P:GND) IC71.10(P:GND) IC72.7(P:GND) IC73.8(GND) IC74.7(P:GND) IC75.10(GND) IC76.10(GND) IC77.10(GND) IC78.10(GND) IC79.10(GND) IC80.7(P:GND) IC81.7(P:GND) IC86.10(GND) IC87.8(P:GND) IC88.10(GND) IC89.10(P:GND) IC90.10(P:GND) IC91.10(P:GND) IC92.10(P:GND) IC98.10(GND) IC99.10(GND) IC100.10(GND) IC101.10(GND) IC102.10(P:GND) IC105.10(P:GND) IC106.10(P:GND) IC107.10(P:GND) IC108.10(P:GND) IC109.10(P:GND) IC110.10(P:GND) IC111.10(P:GND) IC112.10(P:GND) IC113.10(P:GND) IC114.10(P:GND) IC115.10(P:GND) IC116.10(P:GND) IC117.10(P:GND) IC118.10(GND) IC122.10(P:GND) IC123.10(GND) IC124.10(P:GND) IC125.10(P:GND) IC126.10(GND) IC127.8(GND) IC128.8(GND) IC130.7(P:GND) IC131.7(P:GND) IC132.7(P:GND) IC133.7(P:GND) IC134.10(GND) IC135.10(GND) IC136.10(GND) IC137.10(GND) IC138.7(P:GND) IC139.8(GND) IC140.10(GND) IC141.7(P:GND) IC142.8(GND) IC143.7(P:GND) IC145.10(P:GND) IC146.10(P:GND) IC147.7(P:GND) IC148.8(GND) IC149.8(GND) IC150.7(P:GND) IC151.7(P:GND) IC152.8(GND) IC153.10(GND) IC154.10(P:GND) IC155.10(P:GND) IC156.8(GND) IC157.7(P:GND) IC158.7(P:GND) IC159.8(GND) IC160.8(GND) IC161.8(GND) IC162.8(GND) IC163.8(GND) IC164.8(GND) IC165.10(GND) IC166.10(GND) IC167.8(GND) IC168.7(P:GND) IC169.8(GND) IC170.7(P:GND) IC171.8(GND) IC172.8(GND) IC173.8(GND) IC174.7(P:GND) IC175.7(P:GND) IC176.10(P:GND) IC177.7(P:GND) IC178.10(P:GND) IC179.10(P:GND) IC180.10(GND) IC181.10(P:GND) IC182.10(P:GND) IC183.10(P:GND) IC184.10(GND) IC185.10(GND) IC186.10(P:GND) IC187.8(GND) IC188.8(GND) IC189.10(GND) IC190.8(GND) IC191.8(GND) IC192.7(P:GND) IC193.7(P:GND) IC194.10(P:GND) IC195.10(P:GND) IC196.10(P:GND) IC197.7(P:GND) IC198.7(P:GND) IC199.7(P:GND) IC200.7(P:GND) IC209.7(P:GND) IC210.10(P:GND) IC211.10(P:GND) IC212.10(P:GND) IC213.10(P:GND) IC214.10(P:GND) IC215.10(P:GND) IC216.10(GND) IC217.10(P:GND) IC229.10(P:GND) IC230.10(P:GND) IC231.10(P:GND) IC232.10(P:GND) IC233.10(GND) IC234.10(GND) IC235.10(P:GND) IC236.10(P:GND) IC237.10(P:GND) IC238.10(P:GND) IC239.10(GND) IC240.10(GND) IC245.10(P:GND) IC246.10(P:GND) IC247.10(P:GND) IC248.10(P:GND)
VCC: IC1.20(VCC) IC2.20(P:VCC) IC3.20(P:VCC) IC4.20(VCC) IC5.20(VCC) IC6.20(VCC) IC7.20(VCC) IC8.16(VCC) IC9.20(P:VCC) IC10.20(P:VCC) IC11.20(P:VCC) IC12.20(P:VCC) IC13.20(P:VCC) IC14.24(VCC) IC15.24(VCC) IC16.20(VCC) IC17.20(VCC) IC18.14(P:VCC) IC19.20(P:VCC) IC20.20(VCC) IC21.20(VCC) IC22.16(VCC) IC23.16(VCC) IC24.20(P:VCC) IC25.20(P:VCC) IC26.20(P:VCC) IC27.20(P:VCC) IC28.20(P:VCC) IC29.20(P:VCC) IC30.20(P:VCC) IC31.20(P:VCC) IC32.20(VCC) IC33.20(VCC) IC34.16(VCC) IC35.16(VCC) IC36.16(VCC) IC37.16(VCC) IC38.16(VCC) IC39.14(P:VCC) IC40.16(VCC) IC41.16(VCC) IC42.14(P:VCC) IC43.14(P:VCC) IC44.14(P:VCC) IC45.14(P:VCC) IC46.20(VCC) IC47.16(VCC) IC48.20(VCC) IC49.16(VCC) IC50.16(VCC) IC51.16(VCC) IC52.16(VCC) IC53.16(VCC) IC54.14(P:VCC) IC55.16(VCC) IC56.16(VCC) IC57.14(P:VCC) IC58.14(P:VCC) IC59.16(VCC) IC60.20(VCC) IC61.20(VCC) IC62.20(VCC) IC64.14(P:VCC) IC65.14(P:VCC) IC66.14(P:VCC) IC67.14(P:VCC) IC68.16(VCC) IC69.16(VCC) IC70.20(P:VCC) IC71.20(P:VCC) IC72.14(P:VCC) IC73.16(VCC) IC74.14(P:VCC) IC75.20(VCC) IC76.20(VCC) IC77.20(VCC) IC78.20(VCC) IC79.20(VCC) IC80.14(P:VCC) IC81.14(P:VCC) IC86.20(VCC) IC87.16(P:VCC) IC88.20(VCC) IC89.20(P:VCC) IC90.20(P:VCC) IC91.20(P:VCC) IC92.20(P:VCC) IC98.20(VCC) IC99.20(VCC) IC100.20(VCC) IC101.20(VCC) IC102.20(P:VCC) IC105.20(P:VCC) IC106.20(P:VCC) IC107.20(P:VCC) IC108.20(P:VCC) IC109.20(P:VCC) IC110.20(P:VCC) IC111.20(P:VCC) IC112.20(P:VCC) IC113.20(P:VCC) IC114.20(P:VCC) IC115.20(P:VCC) IC116.20(P:VCC) IC117.20(P:VCC) IC118.20(VCC) IC122.20(P:VCC) IC123.20(VCC) IC124.20(P:VCC) IC125.20(P:VCC) IC126.20(VCC) IC127.16(VCC) IC128.16(VCC) IC130.14(P:VCC) IC131.14(P:VCC) IC132.14(P:VCC) IC133.14(P:VCC) IC134.20(VCC) IC135.20(VCC) IC136.20(VCC) IC137.20(VCC) IC138.14(P:VCC) IC139.16(VCC) IC140.20(VCC) IC141.14(P:VCC) IC142.16(VCC) IC143.14(P:VCC) IC145.20(P:VCC) IC146.20(P:VCC) IC147.14(P:VCC) IC148.16(VCC) IC149.16(VCC) IC150.14(P:VCC) IC151.14(P:VCC) IC152.16(VCC) IC153.20(VCC) IC154.20(P:VCC) IC155.20(P:VCC) IC156.16(VCC) IC157.14(P:VCC) IC158.14(P:VCC) IC159.16(VCC) IC160.16(VCC) IC161.16(VCC) IC162.16(VCC) IC163.16(VCC) IC164.16(VCC) IC165.20(VCC) IC166.20(VCC) IC167.16(VCC) IC168.14(P:VCC) IC169.16(VCC) IC170.14(P:VCC) IC171.16(VCC) IC172.16(VCC) IC173.16(VCC) IC174.14(P:VCC) IC175.14(P:VCC) IC176.20(P:VCC) IC177.14(P:VCC) IC178.20(P:VCC) IC179.20(P:VCC) IC180.20(VCC) IC181.20(P:VCC) IC182.20(P:VCC) IC183.20(P:VCC) IC184.20(VCC) IC185.20(VCC) IC186.20(P:VCC) IC187.16(VCC) IC188.16(VCC) IC189.20(VCC) IC190.16(VCC) IC191.16(VCC) IC192.14(P:VCC) IC193.14(P:VCC) IC194.20(P:VCC) IC195.20(P:VCC) IC196.20(P:VCC) IC197.14(P:VCC) IC198.14(P:VCC) IC199.14(P:VCC) IC200.14(P:VCC) IC209.14(P:VCC) IC210.20(P:VCC) IC211.20(P:VCC) IC212.20(P:VCC) IC213.20(P:VCC) IC214.20(P:VCC) IC215.20(P:VCC) IC216.20(VCC) IC217.20(P:VCC) IC229.20(P:VCC) IC230.20(P:VCC) IC231.20(P:VCC) IC232.20(P:VCC) IC233.20(VCC) IC234.20(VCC) IC235.20(P:VCC) IC236.20(P:VCC) IC237.20(P:VCC) IC238.20(P:VCC) IC239.20(VCC) IC240.20(VCC) IC245.20(P:VCC) IC246.20(P:VCC) IC247.20(P:VCC) IC248.20(P:VCC)

## Library data of the parts
IC1 IC4-IC7 IC16 IC17 IC21 IC48 IC86 IC88 IC98-IC101 IC123 IC153 IC180 IC184 IC185 IC189 IC216 IC233 IC234 IC239 IC240 = 74xx-us:74*377: Octal D type FLIP FLOP, enable
IC2 IC3 IC9-IC13 IC24-IC31 IC70 IC71 IC102 IC105-IC117 IC122 IC124 IC125 IC145 IC146 IC154 IC155 IC176 IC178 IC179 IC181-IC183 IC186 IC194-IC196 IC210 IC215 IC245-IC248 = 74xx-us:74*244: Octal BUFFER and LINE DRIVER, 3-state; MF: TEXAS INSTRUMENTS; MPN: SN74LS244N; OC_FARNELL: 1739688
IC8 IC22 IC23 IC47 IC167 = 74xx-us:74*157: Quadruple 2-line to 1-line data SELECTOR/MULTIPLEXER; OC_FARNELL: unknown
IC14 IC15 = 74xx-us:74*181: ARITHMETIC LOGIC UNIT function generator; OC_FARNELL: unknown
IC18 IC67 IC81 IC170 = 74xx-us:74*32: Quad 2-input OR gate; MF: TEXAS INSTRUMENTS; MPN: SN7432N; OC_FARNELL: 1607803
IC19 IC89-IC92 IC211-IC214 IC217 IC229-IC232 IC235-IC238 = 74xx-us:74*244: Octal BUFFER and LINE DRIVER, 3-state; OC_FARNELL: unknown
IC20 IC32 IC33 IC60-IC62 IC75-IC79 IC134-IC137 = 74xx-us:74*273: Octal D type FLIP FLOP, clear; OC_FARNELL: unknown
IC34-IC38 IC40 IC41 IC56 IC142 = 74xx-us:74*153: Dual 4-line to 1-line data SELECTOR/MULTIPLEXER; OC_FARNELL: unknown
IC39 IC66 IC133 IC138 IC143 IC147 IC168 IC200 IC209 = 74xx-us:74*08: Quad 2-input AND gate; OC_FARNELL: unknown
IC42 IC58 IC72 IC74 IC80 IC130 = 74xx-us:74*86: Quad 2-input EXCLUSIV-OR (XOR) gate; OC_FARNELL: unknown
IC43 IC45 IC57 IC65 IC132 IC141 IC150 IC151 IC157 IC158 IC174 IC193 IC198 = 74xx-us:74*04: Hex INVERTER; OC_FARNELL: unknown
IC44 IC54 IC175 IC177 IC192 = 74xx-us:74*74: Dual D type positive edge triggered FLIP FLOP, preset and clear; OC_FARNELL: unknown
IC46 IC126 = 74xx-us:74*377: Octal D type FLIP FLOP, enable; OC_FARNELL: unknown
IC49-IC53 IC55 IC68 IC69 IC127 IC128 IC148 IC149 = 74xx-us:74*283: 4-bit binary FULL ADDER, fast carry; OC_FARNELL: unknown
IC59 IC73 IC152 IC156 IC159-IC164 IC169 IC171-IC173 IC187 IC188 IC190 IC191 = 74xx-us:74*257: Quadruple 2-to 1 line data SELECTOR/MULTIPLEXER; OC_FARNELL: unknown
IC64 IC131 = 74xx-us:74*20: Dual 4-input NAND gate; OC_FARNELL: unknown
IC87 = 74xx-us:74*279: Quadruple S-R LATCH; OC_FARNELL: unknown
IC118 IC140 IC165 IC166 = 74xx-us:74*541: Octal BUFFER and LINE DRIVER, 3-state; OC_FARNELL: unknown
IC139 = 74xx-us:74*173: 4-bit D type REGISTER, 3-state; OC_FARNELL: unknown
IC197 IC199 = 74xx-us:74*260: Dual 5-input positive NOR gate; OC_FARNELL: unknown
R1-R3 = rcl:R-US_: RESISTOR, American symbol; OC_FARNELL: unknown
R4-R8 = resistor-bourns:4816P-T01: BOURNS RESISTOR NETWORK; MF: BOURNS; MPN: 4816P-T01-104LF; OC_FARNELL: 9357483; OC_NEWARK: 33K0707
S1 S2 = switch:TL36PO: TINY SWITCH ON - ON Source: http://www2.produktinfo.conrad.com/datenblaetter/700000-724999/705152-da-01-de-Subminiaturschalter_TL_36YO.pdf; OC_FARNELL: unknown
SW1 SW2 = special:SW_DIP-8: DIP SWITCH; OC_FARNELL: unknown
SW3 = special:SW-C10: SWITCH 10-step rotary switch; OC_FARNELL: unknown
U$1-U$12 = atmel_28c:AT28C256-28DIP: IC EEPROM 256KBIT 150NS 28DIP; OC_FARNELL: unknown